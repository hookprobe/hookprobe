# Repository hookprobe/hookprobe (continued)

## KiCad design hardware/hookprobe-sbc/schematic/hookprobe-sbc.kicad_pcb (continued)

Schematic: pcie_clock.kicad_sch, PCIe reference clock: oscillator and two buffers

Parts:
C460, C462, C465, C468, C471, C474, C484, C486, C489, C492, C495, C498: 1uF; C_0402_1005Metric
C461, C485: 10uF; C_0603_1608Metric
C463, C466, C469, C472, C487, C490, C493, C496: 22uF; C_0603_1608Metric
C464, C467, C470, C473, C475, C476, C477, C478, C479, C480, C481, C482, C483, C488, C491, C494, C497, C499, C500, C501, C502, C503, C504, C505, C506, C507, C508, C509: 100nF; C_0402_1005Metric
FB4: 120R@100MHz 0.6A; L_0402_1005Metric
R149, R172, R187: 10K; R_0402_1005Metric
R150, R151, R152, R153, R154, R155, R173, R174, R175, R176, R177, R178: 1K; R_0402_1005Metric
R156, R158, R160, R162, R164, R166, R168, R170, R179, R181, R183, R185, R188: 33R; R_0402_1005Metric
R157, R159, R161, R163, R165, R167, R169, R171, R180, R182, R184, R186: 49.9R 1%; R_0402_1005Metric
R189, R190: 100R 1%; R_0402_1005Metric
U19, U21: RT9193-33GB; SOT-23-5
U20, U22: Au5426 / LMK00304; WQFN-32_L5.0-W5.0-P0.50-BL-EP; LCSC C200359 (TI LMK00304SQ, pin-compatible)
Y4: 100MHz 3.3V 3225; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutA0_N: R158.1, U20.4 (CLKoutA0*)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutA0_P: R156.1, U20.3 (CLKoutA0)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutA1_N: R166.1, U20.7 (CLKoutA1*)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutA1_P: R164.1, U20.6 (CLKoutA1)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutB0_N: R162.1, U20.21 (CLKoutB0*)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutB0_P: R160.1, U20.22 (CLKoutB0)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutB1_N: R170.1, U20.18 (CLKoutB1*)
/PCIe reference clock: oscillator and two buffers/CKA_CLKoutB1_P: R168.1, U20.19 (CLKoutB1)
/PCIe reference clock: oscillator and two buffers/CKA_IN0_N: C482.1, U20.15 (CLKin0*)
/PCIe reference clock: oscillator and two buffers/CKA_LDO_EN: R149.2, U19.3 (EN)
/PCIe reference clock: oscillator and two buffers/CKA_OSCOUT: C483.1, U20.12 (OSCout)
/PCIe reference clock: oscillator and two buffers/CKA_REFOUT: R155.1, U20.29 (REFout)
/PCIe reference clock: oscillator and two buffers/CKA_REF_EN: R154.1, U20.31 (REFout_EN)
/PCIe reference clock: oscillator and two buffers/CKA_SEL0: R150.1, U20.13 (CLKin_SEL0)
/PCIe reference clock: oscillator and two buffers/CKA_SEL1: R151.1, U20.16 (CLKin_SEL1)
/PCIe reference clock: oscillator and two buffers/CKA_TYPE0: R152.1, U20.9 (CLKout_TYPE0)
/PCIe reference clock: oscillator and two buffers/CKA_TYPE1: R153.2, U20.32 (CLKout_TYPE1)
/PCIe reference clock: oscillator and two buffers/CKB_CLKoutA0_N: R181.1, U22.4 (CLKoutA0*)
/PCIe reference clock: oscillator and two buffers/CKB_CLKoutA0_P: R179.1, U22.3 (CLKoutA0)
/PCIe reference clock: oscillator and two buffers/CKB_CLKoutA1_N: R185.1, U22.7 (CLKoutA1*)
/PCIe reference clock: oscillator and two buffers/CKB_CLKoutA1_P: R183.1, U22.6 (CLKoutA1)
/PCIe reference clock: oscillator and two buffers/CKB_IN0_N: C506.1, U22.15 (CLKin0*)
/PCIe reference clock: oscillator and two buffers/CKB_LDO_EN: R172.2, U21.3 (EN)
/PCIe reference clock: oscillator and two buffers/CKB_OSCOUT: C507.1, U22.12 (OSCout)
/PCIe reference clock: oscillator and two buffers/CKB_REFOUT: R178.1, U22.29 (REFout)
/PCIe reference clock: oscillator and two buffers/CKB_REF_EN: R177.1, U22.31 (REFout_EN)
/PCIe reference clock: oscillator and two buffers/CKB_SEL0: R173.1, U22.13 (CLKin_SEL0)
/PCIe reference clock: oscillator and two buffers/CKB_SEL1: R174.1, U22.16 (CLKin_SEL1)
/PCIe reference clock: oscillator and two buffers/CKB_TYPE0: R175.1, U22.9 (CLKout_TYPE0)
/PCIe reference clock: oscillator and two buffers/CKB_TYPE1: R176.2, U22.32 (CLKout_TYPE1)
/PCIe reference clock: oscillator and two buffers/OSC_BIAS: C509.1, R188.2, R189.2, R190.1
/PCIe reference clock: oscillator and two buffers/OSC_EN: R187.2, Y4.1 (EN)
/PCIe reference clock: oscillator and two buffers/OSC_OUT: R188.1, Y4.3 (OUT)
/PCIe reference clock: oscillator and two buffers/OSC_VDD: C508.1, FB4.2, R187.1, Y4.4 (Vdd)
GEN_CLK_100MHZ: C509.2, U20.14 (CLKin0), U22.14 (CLKin0)
GND: C460.2, C461.2, C462.2, C463.2, C464.2, C465.2, C466.2, C467.2, C468.2, C469.2, C470.2, C471.2, C472.2, C473.2, C474.2, C475.2, C476.2, C477.2, C478.2, C479.2, C480.2, C481.2, C482.2, C483.2, C484.2, C485.2, C486.2, C487.2, C488.2, C489.2, C490.2, C491.2, C492.2, C493.2, C494.2, C495.2, C496.2, C497.2, C498.2, C499.2, C500.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, R150.2, R151.2, R152.2, R154.2, R155.2, R157.2, R159.2, R161.2, R163.2, R165.2, R167.2, R169.2, R171.2, R173.2, R174.2, R175.2, R177.2, R178.2, R180.2, R182.2, R184.2, R186.2, R190.2, U19.2 (GND), U20.1 (GND), U20.8 (GND), U20.17 (GND), U20.24 (GND), U20.33 (EP), U21.2 (GND), U22.1 (GND), U22.8 (GND), U22.17 (GND), U22.24 (GND), U22.33 (EP), Y4.2 (GND); also elsewhere on the board
PCIE30_PHY0_REFCLK_N: R158.2, R159.1; also elsewhere on the board
PCIE30_PHY0_REFCLK_P: R156.2, R157.1; also elsewhere on the board
PCIE30_PHY1_REFCLK_N: R162.2, R163.1; also elsewhere on the board
PCIE30_PHY1_REFCLK_P: R160.2, R161.1; also elsewhere on the board
PCIE_ACCEL_REFCLK_N: R170.2, R171.1; also elsewhere on the board
PCIE_ACCEL_REFCLK_P: R168.2, R169.1; also elsewhere on the board
PCIE_ETH1_REFCLK_N: R181.2, R182.1; also elsewhere on the board
PCIE_ETH1_REFCLK_P: R179.2, R180.1; also elsewhere on the board
PCIE_ETH2_REFCLK_N: R185.2, R186.1; also elsewhere on the board
PCIE_ETH2_REFCLK_P: R183.2, R184.1; also elsewhere on the board
PCIE_NVME_REFCLK_N: R166.2, R167.1; also elsewhere on the board
PCIE_NVME_REFCLK_P: R164.2, R165.1; also elsewhere on the board
VCC3V3_CLKA: C461.1, C462.1, C463.1, C464.1, C465.1, C466.1, C467.1, C468.1, C469.1, C470.1, C471.1, C472.1, C473.1, C474.1, C475.1, C476.1, C477.1, C478.1, C479.1, C480.1, C481.1, FB4.1, R153.1, R189.1, U19.5 (VOUT), U20.2 (VCCOA), U20.5 (VCCOA), U20.10 (VCC), U20.20 (VCCOB), U20.23 (VCCOB), U20.28 (VCC), U20.30 (VCCOC)
VCC3V3_CLKB: C485.1, C486.1, C487.1, C488.1, C489.1, C490.1, C491.1, C492.1, C493.1, C494.1, C495.1, C496.1, C497.1, C498.1, C499.1, C500.1, C501.1, C502.1, C503.1, C504.1, C505.1, R176.1, U21.5 (VOUT), U22.2 (VCCOA), U22.5 (VCCOA), U22.10 (VCC), U22.20 (VCCOB), U22.23 (VCCOB), U22.28 (VCC), U22.30 (VCCOC)
VCC5V0_SYS: C460.1, C484.1, R149.1, R172.1, U19.1 (VIN), U21.1 (VIN); also elsewhere on the board

Notes on the sheet:
Each buffer circuit is copied from the Radxa Rock 5B v1.45 schematic, sheet 7 (Au5426, same pinout as TI LMK00304). Straps as the reference: input 0 selected, HCSL outputs, reference output off. Outputs have 33R in series and 49.9R to ground on each leg. Differences from the reference, to check aga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

Schematic: soc_display.kicad_sch, Processor: display and camera blocks (unused)

Parts:
C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530: 100nF; C_0402_1005Metric
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588

Connections:
GND: C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2; also elsewhere on the board
VCCA_3V3_S0: C519.1, C520.1, U100.AE4 (HDMI_RX_VPH3V3), U100.AE5 (HDMI_RX_DVDD3V3); also elsewhere on the board
VCC_1V8_S0: C512.1, C513.1, C516.1, C517.1, C522.1, C524.1, C527.1, C530.1, U100.AA26 (MIPI_CSI1_AVCC1V8), U100.AB26 (MIPI_CSI0_AVCC1V8), U100.AC6 (HDMI/eDP_TX0_VDD_CMN_1V8), U100.AC7 (HDMI/eDP_TX0_VDD_IO_1V8), U100.AD6 (HDMI/eDP_TX1_VDD_CMN_1V8), U100.AD7 (HDMI/eDP_TX1_VDD_IO_1V8), U100.AJ19 (MIPI_D/C_PHY1_VDD_1V8), U100.AJ20 (MIPI_D/C_PHY0_VDD_1V8); also elsewhere on the board
VDDA_0V75_S0: C510.1, C511.1, C514.1, C515.1, C518.1, U100.AA9 (HDMI/eDP_TX0_VDD_0V75), U100.AB9 (HDMI/eDP_TX0_AVDD_0V75), U100.AC9 (HDMI/eDP_TX1_AVDD_0V75), U100.AD9 (HDMI/eDP_TX1_VDD_0V75), U100.AE8 (HDMI_RX_AVDD0V75); also elsewhere on the board
VDDA_1V2_S0: C526.1, C529.1, U100.AH19 (MIPI_D/C_PHY1_VDD_1V2), U100.AH20 (MIPI_D/C_PHY0_VDD_1V2); also elsewhere on the board
VDD_0V75_S0: C521.1, C523.1, C525.1, C528.1, U100.AA25 (MIPI_CSI1_AVCC0V75), U100.AB25 (MIPI_CSI0_AVCC0V75), U100.AG19 (MIPI_D/C_PHY1_VDD), U100.AG20 (MIPI_D/C_PHY0_VDD); also elsewhere on the board

Notes on the sheet:
RK3588 unit 5: HDMI/eDP transmitters, HDMI receiver, MIPI CSI/DSI. None is used on this board (setup video goes out over USB-C DisplayPort from the Type-C PHYs). Supply pins are powered from the same rails as on the Radxa Rock 5B v1.45 schematic (sheets 16, 17), with one 100 nF each; all signal, RE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

Schematic: usbc1.kicad_sch, USB-C port 1: USB 3, DisplayPort, power in

Parts:
C531, C532, C533, C534, C535, C536, C539, C541: 100nF; C_0402_1005Metric
C537, C538: 220pF; C_0402_1005Metric
C540: 1uF; C_0402_1005Metric
D5, D6, D7: ESD5302F; SOT-23
J10: USB-C; USB_C_Receptacle_Amphenol_12401610E4-2A; Part Amphenol 12401610E4-2A, USB Type-C rece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
R191, R193: 2M; R_0402_1005Metric
R192, R194: 100K; R_0402_1005Metric
R195, R196: 2.2R; R_0402_1005Metric
R197: 4.7K; R_0402_1005Metric
R198: 10K; R_0402_1005Metric
U23, U24: TPD4E05U06; USON-10_2.5x1.0mm_P0.5mm
U25: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm

Connections:
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_AUX_N: C536.2, D7.2 (A2), J10.B8 (SBU2), R193.1, R194.2
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_AUX_P: C535.2, D7.1 (A1), J10.A8 (SBU1), R191.1, R192.2
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_CC1: C537.1, D6.1 (A1), J10.A5 (CC1), U25.10 (CC1), U25.11 (CC1)
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_CC2: C538.1, D6.2 (A2), J10.B5 (CC2), U25.1 (CC2), U25.14 (CC2)
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_CONN_DM: D5.2 (A2), J10.A7 (D-), J10.B7 (D-), R196.2
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_CONN_DP: D5.1 (A1), J10.A6 (D+), J10.B6 (D+), R195.2
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_TX1C_N: C532.2, J10.A3 (TX1-), U23.5 (D2-)
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_TX1C_P: C531.2, J10.A2 (TX1+), U23.4 (D2+)
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_TX2C_N: C534.2, J10.B3 (TX2-), U24.5 (D2-)
/USB-C port 1: USB 3, DisplayPort, power in/USBC1_TX2C_P: C533.2, J10.B2 (TX2+), U24.4 (D2+)
GND: C537.2, C538.2, C539.2, C540.2, C541.2, D5.3 (common), D6.3 (common), D7.3 (common), J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.SH (SHIELD), R191.2, R193.2, U23.3 (GND), U23.8 (GND), U24.3 (GND), U24.8 (GND), U25.8 (GND), U25.9 (GND), U25.15 (GND); also elsewhere on the board
I2C6_SCL_M0: U25.6 (SCL); also elsewhere on the board
I2C6_SDA_M0: U25.7 (SDA); also elsewhere on the board
PD1_INT_L: R198.2, U25.5 (INT_N); also elsewhere on the board
USBC1_SBU1: C535.1; also elsewhere on the board
USBC1_SBU1_DC: R192.1; also elsewhere on the board
USBC1_SBU2: C536.1; also elsewhere on the board
USBC1_SBU2_DC: R194.1; also elsewhere on the board
USBC1_SSRX1_N: J10.B10 (RX1-), U23.2 (D1-); also elsewhere on the board
USBC1_SSRX1_P: J10.B11 (RX1+), U23.1 (D1+); also elsewhere on the board
USBC1_SSRX2_N: J10.A10 (RX2-), U24.2 (D1-); also elsewhere on the board
USBC1_SSRX2_P: J10.A11 (RX2+), U24.1 (D1+); also elsewhere on the board
USBC1_SSTX1_N: C532.1; also elsewhere on the board
USBC1_SSTX1_P: C531.1; also elsewhere on the board
USBC1_SSTX2_N: C534.1; also elsewhere on the board
USBC1_SSTX2_P: C533.1; also elsewhere on the board
USBC1_USB2_DM: R196.1; also elsewhere on the board
USBC1_USB2_DP: R195.1; also elsewhere on the board
USBC1_VBUS: J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS), U25.2 (VBUS); also elsewhere on the board
USBC1_VBUSDET: R197.2; also elsewhere on the board
VCC5V0_SYS: C540.1, C541.1, U25.12 (VCONN), U25.13 (VCONN); also elsewhere on the board
VCCA_3V3_S0: R197.1; also elsewhere on the board
VCC_3V3_S0: R198.1; also elsewhere on the board
VCC_3V3_S3: C539.1, U25.3 (VDD), U25.4 (VDD); also elsewhere on the board

Notes on the sheet:
Copied from the Radxa Rock 5B v1.45 schematic, sheet 29 (its one Type-C port). Port 1 is the power-input port: USBC1_VBUS goes to the power-entry circuit, which is not drawn yet. Left out: the common-mode choke on the USB 2 pair, the zero-ohm links, and the input-voltage ADC divider. ESD parts: TPD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

Schematic: usbc2.kicad_sch, USB-C port 2: USB 3, DisplayPort, power out

Parts:
C542, C543, C544, C545, C546, C547, C550, C552, C555: 100nF; C_0402_1005Metric
C548, C549: 220pF; C_0402_1005Metric
C551, C553: 1uF; C_0402_1005Metric
C554: 10uF; C_0603_1608Metric
D8, D9, D10: ESD5302F; SOT-23
J11: USB-C; USB_C_Receptacle_Amphenol_12401610E4-2A; Part Amphenol 12401610E4-2A, USB Type-C rece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
R199, R201: 2M; R_0402_1005Metric
R200, R202, R207: 100K; R_0402_1005Metric
R203, R204: 2.2R; R_0402_1005Metric
R205: 4.7K; R_0402_1005Metric
R206: 10K; R_0402_1005Metric
R208: 3.4K 1%; R_0402_1005Metric
U26, U27: TPD4E05U06; USON-10_2.5x1.0mm_P0.5mm
U28: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm
U29: SY6280AAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; LCSC C55136

Connections:
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_AUX_N: C547.2, D10.2 (A2), J11.B8 (SBU2), R201.1, R202.2
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_AUX_P: C546.2, D10.1 (A1), J11.A8 (SBU1), R199.1, R200.2
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_CC1: C548.1, D9.1 (A1), J11.A5 (CC1), U28.10 (CC1), U28.11 (CC1)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_CC2: C549.1, D9.2 (A2), J11.B5 (CC2), U28.1 (CC2), U28.14 (CC2)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_CONN_DM: D8.2 (A2), J11.A7 (D-), J11.B7 (D-), R204.2
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_CONN_DP: D8.1 (A1), J11.A6 (D+), J11.B6 (D+), R203.2
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_ISET: R208.1, U29.3 (ISET)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_TX1C_N: C543.2, J11.A3 (TX1-), U26.5 (D2-)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_TX1C_P: C542.2, J11.A2 (TX1+), U26.4 (D2+)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_TX2C_N: C545.2, J11.B3 (TX2-), U27.5 (D2-)
/USB-C port 2: USB 3, DisplayPort, power out/USBC2_TX2C_P: C544.2, J11.B2 (TX2+), U27.4 (D2+)
GND: C548.2, C549.2, C550.2, C551.2, C552.2, C553.2, C554.2, C555.2, D8.3 (common), D9.3 (common), D10.3 (common), J11.A1 (GND), J11.A12 (GND), J11.B1 (GND), J11.B12 (GND), J11.SH (SHIELD), R199.2, R201.2, R207.2, R208.2, U26.3 (GND), U26.8 (GND), U27.3 (GND), U27.8 (GND), U28.8 (GND), U28.9 (GND), U28.15 (GND), U29.2 (GND); also elsewhere on the board
I2C7_SCL_M3: U28.6 (SCL); also elsewhere on the board
I2C7_SDA_M3: U28.7 (SDA); also elsewhere on the board
PD2_INT_L: R206.2, U28.5 (INT_N); also elsewhere on the board
USBC2_SBU1: C546.1; also elsewhere on the board
USBC2_SBU1_DC: R200.1; also elsewhere on the board
USBC2_SBU2: C547.1; also elsewhere on the board
USBC2_SBU2_DC: R202.1; also elsewhere on the board
USBC2_SSRX1_N: J11.B10 (RX1-), U26.2 (D1-); also elsewhere on the board
USBC2_SSRX1_P: J11.B11 (RX1+), U26.1 (D1+); also elsewhere on the board
USBC2_SSRX2_N: J11.A10 (RX2-), U27.2 (D1-); also elsewhere on the board
USBC2_SSRX2_P: J11.A11 (RX2+), U27.1 (D1+); also elsewhere on the board
USBC2_SSTX1_N: C543.1; also elsewhere on the board
USBC2_SSTX1_P: C542.1; also elsewhere on the board
USBC2_SSTX2_N: C545.1; also elsewhere on the board
USBC2_SSTX2_P: C544.1; also elsewhere on the board
USBC2_USB2_DM: R204.1; also elsewhere on the board
USBC2_USB2_DP: R203.1; also elsewhere on the board
USBC2_VBUS: C554.1, C555.1, J11.A4 (VBUS), J11.A9 (VBUS), J11.B4 (VBUS), J11.B9 (VBUS), U28.2 (VBUS), U29.1 (OUT)
USBC2_VBUSDET: R205.2; also elsewhere on the board
USBC2_VBUS_EN: R207.1, U29.4 (EN); also elsewhere on the board
VCC5V0_SYS: C551.1, C552.1, C553.1, U28.12 (VCONN), U28.13 (VCONN), U29.5 (IN); also elsewhere on the board
VCCA_3V3_S0: R205.1; also elsewhere on the board
VCC_3V3_S0: R206.1; also elsewhere on the board
VCC_3V3_S3: C550.1, U28.3 (VDD), U28.4 (VDD); also elsewhere on the board

Notes on the sheet:
Copied from the Radxa Rock 5B v1.45 schematic, sheet 29 (its one Type-C port). Port 2 sources 5 V: SY6280AAC switch as on the reference's USB host port (sheet 27), limit 6800 / 3.4K = 2 A. The reference has no sourcing Type-C port, so this switch arrangement is new for this board. Left out: the com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

Schematic: usb_hub.kicad_sch, USB 2.0 hub and USB-A ports

Parts:
C556, C562: 22uF; C_0603_1608Metric
C557, C558, C560, C564, C565: 100nF; C_0402_1005Metric
C559: 56pF; C_0402_1005Metric
C561: 1uF; C_0402_1005Metric
C563: 10uF; C_0603_1608Metric
D11, D12: ESD; SOT-23
FB5: 120R@100MHz; L_0402_1005Metric
J12: USB-A x2 stacked; USB_A_CUI_UJ2-ADH-TH_Horizontal_Stacked; Part CUI UJ2-ADH-TH, dual stacked USB 2.0 Ty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
R209: 2.7K 1%; R_0402_1005Metric
R210, R212: 10K; R_0402_1005Metric
R211, R213, R215: 100K; R_0402_1005Metric
R214: 1K; R_0402_1005Metric
R216: 3.4K 1%; R_0402_1005Metric
U30: FE1.1s; WQFN-24_L4.0-W4.0-P0.50-TL-EP2.7; LCSC C6776948
U31: SY6280AAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; LCSC C55136
Y5: 12MHz 20pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/USB 2.0 hub and USB-A ports/HUB_3V3: C556.1, FB5.2, U30.20 (VD33F)
/USB 2.0 hub and USB-A ports/HUB_BUSJ: R213.2, U30.18 (BUSJ)
/USB 2.0 hub and USB-A ports/HUB_DRV: R214.2, U30.21 (DRV)
/USB 2.0 hub and USB-A ports/HUB_OVCJ: R210.2, U30.1 (OVCJ)
/USB 2.0 hub and USB-A ports/HUB_REXT: R209.1, U30.13 (REXT)
/USB 2.0 hub and USB-A ports/HUB_VBUSM: C560.1, R212.2, U30.17 (VBUSM)
/USB 2.0 hub and USB-A ports/HUB_VDD5: C557.1, C558.1, C559.1, U30.19 (VDD5)
/USB 2.0 hub and USB-A ports/HUB_XIN: U30.4 (XIN), Y5.3
/USB 2.0 hub and USB-A ports/HUB_XOUT: U30.3 (XOUT), Y5.1
/USB 2.0 hub and USB-A ports/HUB_XRSTJ: R211.2, U30.16 (XRSTJ)
/USB 2.0 hub and USB-A ports/USBA1_DM: D11.2 (A2), J12.2 (D1-), U30.11 (DM1)
/USB 2.0 hub and USB-A ports/USBA1_DP: D11.1 (A1), J12.3 (D1+), U30.12 (DP1)
/USB 2.0 hub and USB-A ports/USBA2_DM: D12.2 (A2), J12.6 (D2-), U30.9 (DM2)
/USB 2.0 hub and USB-A ports/USBA2_DP: D12.1 (A1), J12.7 (D2+), U30.10 (DP2)
/USB 2.0 hub and USB-A ports/USBA_ISET: R216.1, U31.3 (ISET)
/USB 2.0 hub and USB-A ports/USBA_VBUS: C562.1, C563.1, C564.1, C565.1, J12.1 (VBUS1), J12.5 (VBUS2), U31.1 (OUT)
GND: C556.2, C557.2, C558.2, C559.2, C560.2, C561.2, C562.2, C563.2, C564.2, C565.2, D11.3 (common), D12.3 (common), J12.4 (GND1), J12.8 (GND2), J12.SH (Shield), R209.2, R215.2, R216.2, U30.25 (VSS), U31.2 (GND), Y5.2 (G), Y5.4 (G); also elsewhere on the board
USB2_HUB_DM: U30.14 (DMU); also elsewhere on the board
USB2_HUB_DP: U30.15 (DPU); also elsewhere on the board
USB2_MODEM_DM: U30.7 (DM3); also elsewhere on the board
USB2_MODEM_DP: U30.8 (DP3); also elsewhere on the board
USB_HOST_PWREN_H: R215.1, U31.4 (EN); also elsewhere on the board
VCC5V0_SYS: C561.1, U31.5 (IN); also elsewhere on the board
VCC_3V3_S0: FB5.1, R210.1, R211.1, R212.1, R213.1, R214.1; also elsewhere on the board

Notes on the sheet:
Hub copied from the Radxa Rock 5B v1.45 schematic, sheet 9 (FE1.1s, powered from 3.3 V: VDD5 has only its capacitors, as the hub's datasheet requires). USB-A power switch copied from sheet 27. Hub ports: 1 and 2 = USB-A, 3 = USB 2 side of the 5G modem slot, 4 = spare. The USB-A ports are USB 2.0 on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

Schematic: emmc.kicad_sch, eMMC storage

Parts:
C566: 10pF; C_0402_1005Metric
C567: 10uF; C_0603_1608Metric
C568, C569, C571, C572: 100nF; C_0402_1005Metric
C570: 4.7uF; C_0603_1608Metric
C573: 1uF; C_0402_1005Metric
R217, R218, R219: 10K; R_0402_1005Metric
U32: eMMC 153-ball; FBGA-153_L13.0-W11.5-P0.50_KLMAG1JETD-B041; Part Samsung KLMBG2JETD-B041; LCSC C2803245

Connections:
/eMMC storage/EMMC_VDDI: C573.1, U32.C2 (VDDI)
EMMC_CLK: C566.1, U32.M6 (CLK); also elsewhere on the board
EMMC_CMD: R219.2, U32.M5 (CDM); also elsewhere on the board
EMMC_D0: R218.2, U32.A3 (DAT0); also elsewhere on the board
EMMC_D1: U32.A4 (DAT1); also elsewhere on the board
EMMC_D2: U32.A5 (DAT2); also elsewhere on the board
EMMC_D3: U32.B2 (DAT3); also elsewhere on the board
EMMC_D4: U32.B3 (DAT4); also elsewhere on the board
EMMC_D5: U32.B4 (DAT5); also elsewhere on the board
EMMC_D6: U32.B5 (DAT6); also elsewhere on the board
EMMC_D7: U32.B6 (DAT7); also elsewhere on the board
EMMC_DS: U32.H5 (DATA-STROBE); also elsewhere on the board
EMMC_RST_L: R217.2, U32.K5 (RSTN); also elsewhere on the board
GND: C566.2, C567.2, C568.2, C569.2, C570.2, C571.2, C572.2, C573.2, U32.A6 (VSS), U32.C4 (VSS), U32.E7 (VSS), U32.G5 (VSS), U32.H10 (VSS), U32.J5 (VSS), U32.K8 (VSS), U32.N2 (VSS), U32.N5 (VSS), U32.P4 (VSS), U32.P6 (VSS); also elsewhere on the board
VCC_1V8_S3: C570.1, C571.1, C572.1, R217.1, R218.1, R219.1, U32.C6 (VDD), U32.M4 (VDD), U32.N4 (VDD), U32.P3 (VDD), U32.P5 (VDD); also elsewhere on the board
VCC_3V3_S3: C567.1, C568.1, C569.1, U32.E6 (VDDF), U32.F5 (VDDF), U32.J10 (VDDF), U32.K9 (VDDF); also elsewhere on the board

Notes on the sheet:
The reference has a socket for an eMMC module (sheet 25); this board has the chip soldered down. From the reference: 10K pull-ups on reset, data 0 and command to VCC_1V8_S3, 10 pF on the clock, the 3.3 V flash supply from VCC_3V3_S3 and the 1.8 V interface supply from VCC_1V8_S3. Added for a solder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

Schematic: peripherals.kicad_sch, RTC, Thread radio, debug port, fan

Parts:
C574: 12pF; C_0402_1005Metric
C575, C577, C579: 100nF; C_0402_1005Metric
C576: 10uF; C_1206_3216Metric
C578: 10uF; C_0603_1608Metric
C580: 1uF; C_0402_1005Metric
D13, D14: B5819WS; D_SOD-323
D15: 1N5819; D_SOD-123
J13: RTC battery 3 V; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J14: Fan 5 V; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J15: Debug UART 3.3 V; PinHeader_1x03_P2.54mm_Vertical
Q2: AO3416; SOT-23
R220: 47K; R_0402_1005Metric
R221, R224, R226, R227: 10K; R_0402_1005Metric
R222: 1K; R_0402_1005Metric
R223: 0.1R; R_0402_1005Metric
R225: 0R; R_0402_1005Metric
U33: HYM8563TS; TSSOP-8_3x3mm_P0.65mm
U34: ESP32-H2-MINI-1; WIFIM-SMD_61P-L16.6-W13.2-P0.80-ESP32-C6-MINI-1-N4; LCSC C18203134
Y6: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C578.1, C579.1, R221.1, R224.1, R226.1, R227.1, U34.3 (3V3), U34.15 (VBAT); also elsewhere on the board
/RTC, Thread radio, debug port, fan/FAN_GATE: Q2.1 (G), R222.2
/RTC, Thread radio, debug port, fan/FAN_LOW: D15.2 (A), J14.1, Q2.3 (D)
/RTC, Thread radio, debug port, fan/FAN_SRC: Q2.2 (S), R223.1
/RTC, Thread radio, debug port, fan/RTC_BAT: D14.2 (A), J13.1
/RTC, Thread radio, debug port, fan/RTC_OSCI: C574.1, U33.1 (OSCI), Y6.2
/RTC, Thread radio, debug port, fan/RTC_OSCO: U33.2 (OSCO), Y6.1
/RTC, Thread radio, debug port, fan/RTC_VDD: C575.1, D13.1 (K), D14.1 (K), U33.8 (VDD)
/RTC, Thread radio, debug port, fan/THREAD_EN: C580.1, R224.2, R225.2, U34.8 (EN)
/RTC, Thread radio, debug port, fan/THREAD_IO8: R227.2, U34.22 (IO8)
FAN_PWM: R222.1; also elsewhere on the board
GND: C574.2, C575.2, C576.2, C577.2, C578.2, C579.2, C580.2, J13.2, J15.1, R223.2, U33.4 (VSS), U34.1 (GND), U34.2 (GND), U34.11 (GND), U34.14 (GND), U34.36 (GND), U34.37 (GND), U34.38 (GND), U34.39 (GND), U34.40 (GND), U34.41 (GND), U34.42 (GND), U34.43 (GND), U34.44 (GND), U34.45 (GND), U34.46 (GND), U34.47 (GND), U34.48 (GND), U34.49 (GND), U34.50 (GND), U34.51 (GND), U34.52 (GND), U34.53 (GND); also elsewhere on the board
I2C6_SCL_M0: U33.6 (SCL); also elsewhere on the board
I2C6_SDA_M0: U33.5 (SDA); also elsewhere on the board
RTC_INT_L: R220.2, U33.3 (~INT); also elsewhere on the board
SUSCLK_32K: R221.2, U33.7 (CLKO); also elsewhere on the board
THREAD_BOOT: R226.2, U34.23 (IO9); also elsewhere on the board
THREAD_RESET_L: R225.1; also elsewhere on the board
UART2_RX_DEBUG: J15.3; also elsewhere on the board
UART2_TX_DEBUG: J15.2; also elsewhere on the board
UART3_RX_THREAD: U34.31 (TXD0); also elsewhere on the board
UART3_TX_THREAD: U34.30 (RXD0); also elsewhere on the board
VCC5V0_SYS: C576.1, C577.1, D15.1 (K), J14.2; also elsewhere on the board
VCC_1V8_S3: R220.1; also elsewhere on the board
VCC_3V3_S3: D13.2 (A); also elsewhere on the board

Notes on the sheet:
RTC: copied from the Radxa Rock 5B v1.45 schematic, sheet 5 (HYM8563, pin-compatible with PCF8563). Its 32 kHz output also feeds the Wi-Fi slot; the pull-up goes to +3V3 here (1.8 V on the reference). Fan: copied from sheet 20 (low-side switch on GPIO0_C0 with a flyback diode). Thread / Matter radi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

Schematic: power_entry.kicad_sch, Power entry: DC jack and USB-C input

Parts:
C581, C582, C583, C584: 100nF 50V; C_0603_1608Metric
D16: SMBJ20A; D_SMB
F1: 8 A; Fuse_1206_3216Metric
J16: DC in 12-19 V; BarrelJack_CUI_PJ-063AH_Horizontal; Part CUI PJ-063AH footprint; confirm an 8 A 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
Q3, Q4: BSC028N06LS3; TDSON-8-1; Part 60 V, 2.8 mOhm N-channel MOSFET, 5x6 mm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
U35, U36: LM74700-Q1; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C2941042

Connections:
/Power entry: DC jack and USB-C input/DC_IN: C581.2, C582.1, F1.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), U35.3 (EN), U35.6 (ANODE)
/Power entry: DC jack and USB-C input/DC_JACK: F1.1, J16.1
/Power entry: DC jack and USB-C input/OR1_GATE: Q3.4 (G), U35.5 (GATE)
/Power entry: DC jack and USB-C input/OR1_VCAP: C581.1, U35.1 (VCAP)
/Power entry: DC jack and USB-C input/OR2_GATE: Q4.4 (G), U36.5 (GATE)
/Power entry: DC jack and USB-C input/OR2_VCAP: C583.1, U36.1 (VCAP)
GND: C582.2, C584.2, D16.2 (A2), J16.2, U35.2 (GND), U36.2 (GND); also elsewhere on the board
USBC1_VBUS: C583.2, C584.1, Q4.1 (S), Q4.2 (S), Q4.3 (S), U36.3 (EN), U36.6 (ANODE); also elsewhere on the board
VIN: D16.1 (A1), Q3.5 (D), Q4.5 (D), U35.4 (CATHODE), U36.4 (CATHODE); also elsewhere on the board

Notes on the sheet:
NEW FOR THIS BOARD, not copied from the reference (which has a single USB-C input wired straight to its converters). Each source reaches VIN through an ideal diode: LM74700-Q1 driving an N-channel MOSFET, wired as its datasheet's typical application (source = ANODE = input, drain = CATHODE = VIN, E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
DC jack
USB-C port 1

Schematic: tpm.kicad_sch, TPM 2.0 security chip

Parts:
C585, C586: 100nF; C_0402_1005Metric
C587: 1uF; C_0402_1005Metric
Q5: BSS138; SOT-23
R228, R229, R230: 10K; R_0402_1005Metric
U37: SLB 9670VQ2.0; PG-VQFN-32_L5.0-W5.0-P0.50-BL-EP3.6; LCSC C539131

Connections:
GND: C585.2, C586.2, C587.2, U37.2 (GND), U37.9 (GND), U37.23 (GND), U37.32 (GND), U37.33 (EP); also elsewhere on the board
RESET_L: Q5.2 (S); also elsewhere on the board
SPI1_CLK_TPM: U37.19 (SCLK); also elsewhere on the board
SPI1_CS0_TPM: R229.2, U37.20 (~CS); also elsewhere on the board
SPI1_MISO_TPM: U37.24 (MISO); also elsewhere on the board
SPI1_MOSI_TPM: U37.21 (MOSI); also elsewhere on the board
TPM_INT_L: R228.2, U37.18 (~PIRQ); also elsewhere on the board
TPM_RST_L: Q5.3 (D), R230.2, U37.17 (~RST)
VCC_1V8_S3: Q5.1 (G); also elsewhere on the board
VCC_3V3_S0: C585.1, C586.1, C587.1, R228.1, R229.1, R230.1, U37.8 (VDD), U37.22 (VDD); also elsewhere on the board

Notes on the sheet:
NEW FOR THIS BOARD. Infineon SLB 9670 (the SLB 9672 was not found at LCSC), wired as the typical schematic in its datasheet (vendor/lcsc_C539131): SPI, 100 nF at each VDD pin plus 1 uF, GPIO and PP left open. Runs from VCC_3V3_S0, the same supply as the processor's GPIO bank 3 it talks to. TPM rese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

Board: 8 copper layers, 945 parts (427 on the bottom side), 595 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: Cooler M2.5; MountingHole_2.7mm_M2.5
H5, H6, H7, H8: M3; MountingHole_3.2mm_M3_Pad_Via
H120, H122, H124, H126: M.2 standoff M2; MountingHole_2.2mm_M2_Pad_Via

Their connections:
GND: H5.1, H6.1, H7.1, H8.1, H120.1, H122.1, H124.1, H126.1; also elsewhere on the board

File hardware/hookprobe-sbc/docs/hookprobe-sbc-bom.csv (part):

"Reference","Value","Footprint","LCSC","Part","Qty"
"C1,C2,C7,C8,C13,C14,C264,C275,C286,C297,C308","220nF","Capacitor_SMD:C_0402_1005Metric","","","11"
"C3,C4,C9,C10,C15,C16,C19,C20,C23,C25,C33,C34,C42,C43,C50,C51,C59,C61,C62,C71,C73,C74,C83,C85,C92,C96,C97,C98,C99,C100,C101,C102,C106,C107,C108,C109,C110,C117,C125,C126,C127,C130,C131,C132,C133,C134,C135,C136,C140,C141,C142,C143,C144,C151,C159,C160,C161,C258,C270,C271,C281,C282,C292,C293,C303,C304,C314,C315,C319,C320,C321,C328,C330,C333,C334,C335,C336,C337,C338,C339,C345,C346,C347,C348,C349,C350,C351,C352,C353,C354,C360,C361,C362,C363,C364,C365,C366,C367,C368,C369,C370,C371,C372,C373,C377,C378,C379,C387,C389,C392,C393,C394,C395,C396,C397,C398,C404,C405,C406,C407,C408,C409,C410,C411,C412,C413,C419,C420,C421,C422,C423,C424,C425,C426,C427,C428,C429,C430,C431,C432,C434,C436,C437,C438,C440,C441,C442,C443,C445,C446,C447,C448,C449,C450,C451,C452,C453,C454,C455,C458,C464,C467,C470,C473,C475,C476,C477,C478,C479,C480,C481,C482,C483,C488,C491,C494,C497,C499,C500,C501,C502,C503,C504,C505,C506,C507,C508,C509,C510,C511,C512,C513,C514,C515,C516,C517,C518,C519,C520,C521,C522,C523,C524,C525,C526,C527,C528,C529,C530,C531,C532,C533,C534,C535,C536,C539,C541,C542,C543,C544,C545,C546,C547,C550,C552,C555,C557,C558,C560,C564,C565,C568,C569,C571,C572,C575,C577,C579,C585,C586","100nF","Capacitor_SMD:C_0402_1005Metric","","","240"
"C5,C6,C11,C12,C17,C18,C118,C152,C162,C168,C174,C180,C230,C231,C238,C239,C246,C247,C266,C267,C268,C269,C277,C278,C279,C280,C288,C289,C290,C291,C299,C300,C301,C302,C310,C311,C312,C313","22uF","Capacitor_SMD:C_0805_2012Metric","","","38"
"C21,C22","100uF","Capacitor_SMD:C_1210_3225Metric","","","2"
"C24","33pF","Capacitor_SMD:C_0402_1005Metric","","","1"
"C26,C27,C28,C36,C37,C45,C46,C53,C54,C55,C56,C68,C69,C70,C80,C81,C82,C89,C90,C91,C166,C167,C170,C171,C172,C173,C176,C177,C178,C179,C182,C183,C184,C185,C187,C188,C192,C193,C197,C198,C200,C201,C203,C204,C208,C209,C233,C234,C235,C236,C237,C241,C242,C243,C244,C245,C251,C252,C253,C254,C257,C340,C355,C399,C414,C463,C466,C469,C472,C487,C490,C493,C496,C556,C562","22uF","Capacitor_SMD:C_0603_1608Metric","","","75"
"C29,C30,C38,C39,C47,C48,C57,C66,C67,C78,C79,C87,C88","10uF","Capacitor_SMD:C_0402_1005Metric","","","13"
"C31,C40,C65,C77,C86,C225,C327,C386","4.7uF","Capacitor_SMD:C_0402_1005Metric","","","8"
"C32,C35,C41,C44,C49,C52,C58,C60,C63,C64,C72,C75,C76,C84,C93,C115,C149,C163,C169,C175,C181,C190,C210,C211,C212,C213,C214,C215,C216,C217,C221,C224,C226,C232,C240,C248,C265,C276,C287,C298,C309,C317,C318,C322,C323,C324,C325,C329,C343,C344,C358,C359,C375,C376,C380,C382,C383,C384,C388,C402,C403,C417,C418,C433,C435,C439,C444,C460,C462,C465,C468,C471,C474,C484,C486,C489,C492,C495,C498,C540,C551,C553,C561,C573,C580,C587","1uF","Capacitor_SMD:C_0402_1005Metric","","","86"
"C94,C95,C128,C129","27pF","Capacitor_SMD:C_0402_1005Metric","","","4"
"C103,C137","22pF","Capacitor_SMD:C_0402_1005Metric","","","2"
"C104,C116,C119,C120,C138,C150,C153,C154","10uF","Capacitor_SMD:C_0805_2012Metric","","","8"
"C105,C139","4.7uF","Capacitor_SMD:C_0805_2012Metric","","","2"
"C111,C112,C113,C114,C121,C122,C123,C124,C145,C146,C147,C148,C155,C156,C157,C158,C218,C219,C220,C222,C223","2.2uF","Capacitor_SMD:C_0402_1005Metric","","","21"
"C164,C165,C249,C250","47uF","Capacitor_SMD:C_0805_2012Metric","","","4"
"C186,C189,C191,C194,C196,C199,C202,C205,C207,C255,C259,C260,C316,C326,C331,C332,C341,C342,C356,C357,C374,C381,C385,C390,C391,C400,C401,C415,C416,C461,C485,C554,C563,C567,C578","10uF","Capacitor_SMD:C_0603_1608Metric","","","35"
"C195,C206,C256","100pF","Capacitor_SMD:C_0402_1005Metric","","","3"
"C227,C228,C459","1nF","Capacitor_SMD:C_0402_1005Metric","","","3"
"C229","10nF","Capacitor_SMD:C_0402_1005Metric","","","1"
"C261,C262,C272,C273,C283,C284,C294,C295,C305,C306","10uF 25V","Capacitor_SMD:C_1206_3216Metric","","","10"
"C263,C274,C285,C296,C307,C581,C582,C583,C584","100nF 50V","Capacitor_SMD:C_0603_1608Metric","","","9"
"C456,C457","18pF","Capacitor_SMD:C_0402_1005Metric","","","2"
"C537,C538,C548,C549","220pF","Capacitor_SMD:C_0402_1005Metric","","","4"
"C559","56pF","Capacitor_SMD:C_0402_1005Metric","","","1"
"C566","10pF","Capacitor_SMD:C_0402_1005Metric","","","1"
"C570","4.7uF","Capacitor_SMD:C_0603_1608Metric","","","1"
"C574","12pF","Capacitor_SMD:C_0402_1005Metric","","","1"
"C576","10uF","Capacitor_SMD:C_1206_3216Metric","","","1"
"D1,D13,D14","B5819WS","Diode_SMD:D_SOD-323","","","3"
"D2","AZ5825-01F","Diode_SMD:D_0402_1005Metric","","","1"
"D3,D4","BZT52C3V6S","Diode_SMD:D_SOD-323","","","2"
"D5,D6,D7,D8,D9,D10","ESD5302F","Package_TO_SOT_SMD:SOT-23","","","6"
"D11,D12","ESD","Package_TO_SOT_SMD:SOT-23","","","2"
"D15","1N5819","Diode_SMD:D_SOD-123","","","1"
"D16","SMBJ20A","Diode_SMD:D_SMB","","","1"
"F1","8 A","Fuse:Fuse_1206_3216Metric","","","1"
"FB1,FB2","120R@100MHz 1.3A","Inductor_SMD:L_0402_1005Metric","","UPZ1005D121-1R3TF","2"
"FB3","120R@100MHz","Inductor_SMD:L_0603_1608Metric","","","1"
"FB4","120R@100MHz 0.6A","Inductor_SMD:L_0402_1005Metric","","","1"
"FB5","120R@100MHz","Inductor_SMD:L_0402_1005Metric","","","1"
"J1","NVMe (M-key)","hookprobe:PCIE-SMD_75P-P0.50_1-2199230-5","C590854","TE 1-2199230-5, M.2 M-key socket, 4.2 mm","1"
"J2","Accelerator (M-key)","hookprobe:PCIE-SMD_75P-P0.50_1-2199230-5","C590854","TE 1-2199230-5, M.2 M-key socket, 4.2 mm","1"
"J3","Wi-Fi (E-key)","hookprobe:CONN-SMD_67P-P0.50-V_NXSE0-S67XX-XXH4","C367027","Argosy NASE0-S6701-TSH4, M.2 E-key socket","1"
"J4","5G modem (B-key)","hookprobe:PCIE-SMD_2199230-3_1","C590859","TE 2199230-3, M.2 B-key socket, 4.2 mm","1"
"J5","nano-SIM","Connector_Card:nanoSIM_GCT_SIM8060-6-0-14-00","","","1"
"J6,J7","HR911130C","hookprobe:RJ45-TH_HR911130C","C50933","","2"
"J8","Power / reset buttons","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","","","1"
"J9","USB download","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","","","1"
"J10,J11","USB-C","Connector_USB:USB_C_Receptacle_Amphenol_12401610E4-2A","","Amphenol 12401610E4-2A, USB Type-C receptacle, 24 positions","2"
"J12","USB-A x2 stacked","Connector_USB:USB_A_CUI_UJ2-ADH-TH_Horizontal_Stacked","","CUI UJ2-ADH-TH, dual stacked USB 2.0 Type-A receptacle","1"
"J13","RTC battery 3 V","Connector_JST:JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical","","","1"
"J14","Fan 5 V","Connector_JST:JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical","","","1"
"J15","Debug UART 3.3 V","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","","","1"
"J16","DC in 12-19 V","Connector_BarrelJack:BarrelJack_CUI_PJ-063AH_Horizontal","","CUI PJ-063AH footprint; confirm an 8 A rated jack","1"
"L1,L2","1uH","Inductor_SMD:L_0805_2012Metric","","","2"
"L3,L4,L5,L6,L13,L14,L15","0.22uH","Inductor_SMD:L_1210_3225Metric","","","7"
"L7,L8,L9,L10,L11,L12","0.47uH","Inductor_SMD:L_1210_3225Metric","","","6"
"L16","2.2uH","Inductor_SMD:L_1210_3225Metric","","","1"
"L17,L18,L19,L20,L21","1.5uH 10A","Inductor_SMD:L_1210_3225Metric","","","5"
"Q1","2N7002","Package_TO_SOT_SMD:SOT-23","","","1"
"Q2","AO3416","Package_TO_SOT_SMD:SOT-23","","","1"
"Q3,Q4","BSC028N06LS3","Package_TO_SOT_SMD:TDSON-8-1","","60 V, 2.8 mOhm N-channel MOSFET, 5x6 mm; or an equivalent","2"
"Q5","BSS138","Package_TO_SOT_SMD:SOT-23","","","1"
"R1,R2,R3,R4","10k","Resistor_SMD:R_0402_1005Metric","","","4"
"R5,R27,R43,R57,R58,R64,R70,R72,R77,R78,R79,R84,R85,R87,R91,R92,R94,R98,R99,R101,R105,R106,R132,R135,R137,R192,R194,R200,R202,R207,R211,R213,R215","100K","Resistor_SMD:R_0402_1005Metric","","","33"
"R6,R7,R9,R11,R12,R13","200R 1%","Resistor_SMD:R_0402_1005Metric","","","6"
"R8,R10,R83","8.2K 1%","Resistor_SMD:R_0402_1005Metric","","","3"
"R14,R30","2.49K 1%","Resistor_SMD:R_0402_1005Metric","","","2"
"R15,R31,R150,R151,R152,R153,R154,R155,R173,R174,R175,R176,R177,R178,R214,R222","1K","Resistor_SMD:R_0402_1005Metric","","","16"
"R16,R32","15K 1%","Resistor_SMD:R_0402_1005Metric","","","2"
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