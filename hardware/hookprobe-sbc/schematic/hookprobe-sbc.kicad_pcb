# Repository hookprobe/hookprobe (continued)

## KiCad design hardware/hookprobe-sbc/schematic/hookprobe-sbc.kicad_pcb (continued)

Schematic: power_input.kicad_sch, Input converters: 5 V, 4 V and three 3.3 V rails

Parts:
C261, C262, C272, C273, C283, C284, C294, C295, C305, C306: 10uF 25V; C_1206_3216Metric
C263, C274, C285, C296, C307: 100nF 50V; C_0603_1608Metric
C264, C275, C286, C297, C308: 220nF; C_0402_1005Metric
C265, C276, C287, C298, C309: 1uF; C_0402_1005Metric
C266, C267, C268, C269, C277, C278, C279, C280, C288, C289, C290, C291, C299, C300, C301, C302, C310, C311, C312, C313: 22uF; C_0805_2012Metric
C270, C271, C281, C282, C292, C293, C303, C304, C314, C315: 100nF; C_0402_1005Metric
D3, D4: BZT52C3V6S; D_SOD-323
L17, L18, L19, L20, L21: 1.5uH 10A; L_1210_3225Metric
R72, R77, R78, R79, R84, R85, R87, R91, R92, R94, R98, R99, R101, R105, R106: 100K; R_0402_1005Metric
R73, R80: 75K; R_0402_1005Metric
R74, R81, R88, R95, R102: 3.3R; R_0402_1005Metric
R75, R82, R89, R96, R103: 47K 1%; R_0402_1005Metric
R76: 6.34K 1%; R_0402_1005Metric
R83: 8.2K 1%; R_0402_1005Metric
R86, R93, R100: 10K; R_0402_1005Metric
R90, R97, R104: 10.2K 1%; R_0402_1005Metric
U12, U13, U14, U15, U16: MP8759GD-Z; QFN-12_L3.0-W2.0-P0.5-TL_NB680; LCSC C3187827

Connections:
+3V3: C288.1, C289.1, C290.1, C291.1, C292.1, C293.1, L19.2, R89.1, U14.5 (VOUT); also elsewhere on the board
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_BST: R74.1, U12.8 (BST)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_BSTC: C264.1, R74.2
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_EN: D3.1 (K), R72.2, R73.1, U12.12 (EN)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_FB: R75.2, R76.1, U12.11 (FB)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_MODE: R78.2, U12.6 (MODE)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_PG: R77.2, U12.3 (PG)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_SW: C264.2, L17.1, U12.7 (SW)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN1_VCC: C265.1, R77.1, R78.1, U12.9 (VCC)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_BST: R81.1, U13.8 (BST)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_BSTC: C275.1, R81.2
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_EN: D4.1 (K), R79.2, R80.1, U13.12 (EN)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_FB: R82.2, R83.1, U13.11 (FB)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_MODE: R85.2, U13.6 (MODE)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_PG: R84.2, U13.3 (PG)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_SW: C275.2, L18.1, U13.7 (SW)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN2_VCC: C276.1, R84.1, R85.1, U13.9 (VCC)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_BST: R88.1, U14.8 (BST)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_BSTC: C286.1, R88.2
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_EN: R86.2, R87.1, U14.12 (EN)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_FB: R89.2, R90.1, U14.11 (FB)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_MODE: R92.2, U14.6 (MODE)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_PG: R91.2, U14.3 (PG)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_SW: C286.2, L19.1, U14.7 (SW)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN3_VCC: C287.1, R91.1, R92.1, U14.9 (VCC)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_BST: R95.1, U15.8 (BST)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_BSTC: C297.1, R95.2
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_EN: R93.2, R94.1, U15.12 (EN)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_FB: R96.2, R97.1, U15.11 (FB)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_MODE: R99.2, U15.6 (MODE)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_PG: R98.2, U15.3 (PG)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_SW: C297.2, L20.1, U15.7 (SW)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN4_VCC: C298.1, R98.1, R99.1, U15.9 (VCC)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_BST: R102.1, U16.8 (BST)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_BSTC: C308.1, R102.2
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_EN: R100.2, R101.1, U16.12 (EN)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_FB: R103.2, R104.1, U16.11 (FB)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_MODE: R106.2, U16.6 (MODE)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_PG: R105.2, U16.3 (PG)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_SW: C308.2, L21.1, U16.7 (SW)
/Input converters: 5 V, 4 V and three 3.3 V rails/IN5_VCC: C309.1, R105.1, R106.1, U16.9 (VCC)
GND: C261.2, C262.2, C263.2, C265.2, C266.2, C267.2, C268.2, C269.2, C270.2, C271.2, C272.2, C273.2, C274.2, C276.2, C277.2, C278.2, C279.2, C280.2, C281.2, C282.2, C283.2, C284.2, C285.2, C287.2, C288.2, C289.2, C290.2, C291.2, C292.2, C293.2, C294.2, C295.2, C296.2, C298.2, C299.2, C300.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, D3.2 (A), D4.2 (A), R73.2, R76.2, R80.2, R83.2, R87.2, R90.2, R94.2, R97.2, R101.2, R104.2, U12.2 (PGND), U12.10 (AGND), U13.2 (PGND), U13.10 (AGND), U14.2 (PGND), U14.10 (AGND), U15.2 (PGND), U15.10 (AGND), U16.2 (PGND), U16.10 (AGND); also elsewhere on the board
MODEM_VCC_EN: R100.1; also elsewhere on the board
VCC4V0_SYS: C277.1, C278.1, C279.1, C280.1, C281.1, C282.1, L18.2, R82.1, U13.5 (VOUT); also elsewhere on the board
VCC5V0_SYS: C266.1, C267.1, C268.1, C269.1, C270.1, C271.1, L17.2, R75.1, U12.5 (VOUT); also elsewhere on the board
VCC_3V3_M2: C299.1, C300.1, C301.1, C302.1, C303.1, C304.1, L20.2, R96.1, U15.5 (VOUT); also elsewhere on the board
VCC_3V3_S0: R86.1, R93.1; also elsewhere on the board
VCC_MODEM: C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, L21.2, R103.1, U16.5 (VOUT); also elsewhere on the board
VIN: C261.1, C262.1, C263.1, C272.1, C273.1, C274.1, C283.1, C284.1, C285.1, C294.1, C295.1, C296.1, C305.1, C306.1, C307.1, R72.1, R79.1, U12.1 (VIN), U13.1 (VIN), U14.1 (VIN), U15.1 (VIN), U16.1 (VIN); also elsewhere on the board

Notes on the sheet:
Five MP8759 converters, each copied from the 5 V stage of the Radxa Rock 5B v1.45 schematic, sheet 20. Differences from the reference, to be checked against the MP8759 datasheet before layout: - all five run directly from VIN (the reference feeds its 4 V stage from the 5 V rail); - the three 3.3 V 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
5.05 V: USB ports (5.25 V is the limit with tolerances). On whenever VIN is present
4.04 V: power chip and core regulators. On whenever VIN is present
3.36 V: Wi-Fi, Ethernet, logic. Follows VCC_3V3_S0
3.36 V: NVMe and accelerator slots. Follows VCC_3V3_S0
3.36 V: 5G modem. Switched by software (MODEM_VCC_EN)

Schematic: ddr0.kicad_sch, Memory channel 0: LPDDR4X

Parts:
C316, C326, C331, C332, C341, C342, C356, C357: 10uF; C_0603_1608Metric
C317, C318, C322, C323, C324, C325, C329, C343, C344, C358, C359: 1uF; C_0402_1005Metric
C319, C320, C321, C328, C330, C333, C334, C335, C336, C337, C338, C339, C345, C346, C347, C348, C349, C350, C351, C352, C353, C354, C360, C361, C362, C363, C364, C365, C366, C367, C368, C369, C370, C371, C372, C373: 100nF; C_0402_1005Metric
C327: 4.7uF; C_0402_1005Metric
C340, C355: 22uF; C_0603_1608Metric
NT8: sense tie; NetTie-2_SMD_Pad0.5mm
R107, R108, R109, R110: 49.9R 1%; R_0402_1005Metric
R111, R112, R113, R114: 240R 1%; R_0402_1005Metric
R115, R116: 10K; R_0402_1005Metric
R117, R118: 0R; R_0402_1005Metric
U17: LPDDR4X 200-ball; BGA-200_L15.0-W10.0_K4F8E304HB-MGCJ; Part Samsung K4UBE3D4AA-MGCL (4 GB); any JED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; LCSC C2920257
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588

Connections:
/Memory channel 0: LPDDR4X/DDR_CH0_CKE0_A_SOC: R107.1, U100.P7 (DDR_CH0_LP4/4X_CKE0/LP5_CS0_A)
/Memory channel 0: LPDDR4X/DDR_CH0_CKE0_B_SOC: R108.1, U100.L5 (DDR_CH0_LP4/4X_CKE0/LP5_CS0_B)
/Memory channel 0: LPDDR4X/DDR_CH0_CKE1_A_SOC: R109.1, U100.N7 (DDR_CH0_LP4/4X_CKE1/LP5_CS1_A)
/Memory channel 0: LPDDR4X/DDR_CH0_CKE1_B_SOC: R110.1, U100.L4 (DDR_CH0_LP4/4X_CKE1/LP5_CS1_B)
/Memory channel 0: LPDDR4X/ODT_A: R115.1, U17.G2 (ODT_CA_a)
/Memory channel 0: LPDDR4X/ODT_B: R116.1, U17.T2 (ODT_CA_b)
/Memory channel 0: LPDDR4X/ZQ_MEM0_0: R113.1, U17.A5 (ZQ0)
/Memory channel 0: LPDDR4X/ZQ_MEM0_1: R114.1, U17.A8 (ZQ1)
/Memory channel 0: LPDDR4X/ZQ_SOC_A: R111.1, U100.W8 (DDR_CH0_ZQ_A)
/Memory channel 0: LPDDR4X/ZQ_SOC_B: R112.1, U100.H7 (DDR_CH0_ZQ_B)
DDR_CH0_A0_A: U17.H2 (CA0_a), U100.T7 (DDR_CH0_A0_A)
DDR_CH0_A0_B: U17.R2 (CA0_b), U100.M8 (DDR_CH0_A0_B)
DDR_CH0_A1_A: U17.J2 (CA1_a), U100.T8 (DDR_CH0_A1_A)
DDR_CH0_A1_B: U17.P2 (CA1_b), U100.M5 (DDR_CH0_A1_B)
DDR_CH0_A2_A: U17.H9 (CA2_a), U100.P4 (DDR_CH0_A2_A)
DDR_CH0_A2_B: U17.R9 (CA2_b), U100.N5 (DDR_CH0_A2_B)
DDR_CH0_A3_A: U17.H10 (CA3_a), U100.P5 (DDR_CH0_A3_A)
DDR_CH0_A3_B: U17.R10 (CA3_b), U100.N4 (DDR_CH0_A3_B)
DDR_CH0_A4_A: U17.H11 (CA4_a), U100.R1 (DDR_CH0_A4_A)
DDR_CH0_A4_B: U17.R11 (CA4_b), U100.K1 (DDR_CH0_A4_B)
DDR_CH0_A5_A: U17.J11 (CA5_a), U100.P2 (DDR_CH0_A5_A)
DDR_CH0_A5_B: U17.P11 (CA5_b), U100.L2 (DDR_CH0_A5_B)
DDR_CH0_CKE0_A: R107.2, U17.J4 (CKE0_a)
DDR_CH0_CKE0_B: R108.2, U17.P4 (CKE0_b)
DDR_CH0_CKE1_A: R109.2, U17.J5 (CKE1_a)
DDR_CH0_CKE1_B: R110.2, U17.P5 (CKE1_b)
DDR_CH0_CLKN_A: U17.J9 (CK_c_a), U100.N1 (DDR_CH0_CKB_A)
DDR_CH0_CLKN_B: U17.P9 (CK_c_b), U100.M1 (DDR_CH0_CKB_B)
DDR_CH0_CLKP_A: U17.J8 (CK_t_a), U100.N2 (DDR_CH0_CK_A)
DDR_CH0_CLKP_B: U17.P8 (CK_t_b), U100.M2 (DDR_CH0_CK_B)
DDR_CH0_CS0_A: U17.H4 (CS0_a), U100.R6 (DDR_CH0_LP4/4X_CS0_A)
DDR_CH0_CS0_B: U17.R4 (CS0_b), U100.L7 (DDR_CH0_LP4/4X_CS0_B)
DDR_CH0_CS1_A: U17.H3 (CS1_a), U100.R7 (DDR_CH0_LP4/4X_CS1_A)
DDR_CH0_CS1_B: U17.R3 (CS1_b), U100.L8 (DDR_CH0_LP4/4X_CS1_B)
DDR_CH0_DM0_A: U17.C3 (DMI0_a), U100.Y4 (DDR_CH0_DM0_A)
DDR_CH0_DM0_B: U17.Y3 (DMI0_b), U100.G4 (DDR_CH0_DM0_B)
DDR_CH0_DM1_A: U17.C10 (DMI1_a), U100.AB4 (DDR_CH0_DM1_A)
DDR_CH0_DM1_B: U17.Y10 (DMI1_b), U100.E4 (DDR_CH0_DM1_B)
DDR_CH0_DQ0_A: U17.B2 (DQ0_a), U100.U1 (DDR_CH0_DQ0_A)
DDR_CH0_DQ0_B: U17.AA2 (DQ0_b), U100.H1 (DDR_CH0_DQ0_B)
DDR_CH0_DQ1_A: U17.C2 (DQ1_a), U100.T2 (DDR_CH0_DQ1_A)
DDR_CH0_DQ1_B: U17.Y2 (DQ1_b), U100.J2 (DDR_CH0_DQ1_B)
DDR_CH0_DQ2_A: U17.E2 (DQ2_a), U100.T1 (DDR_CH0_DQ2_A)
DDR_CH0_DQ2_B: U17.V2 (DQ2_b), U100.J1 (DDR_CH0_DQ2_B)
DDR_CH0_DQ3_A: U17.F2 (DQ3_a), U100.R2 (DDR_CH0_DQ3_A)
DDR_CH0_DQ3_B: U17.U2 (DQ3_b), U100.K2 (DDR_CH0_DQ3_B)
DDR_CH0_DQ4_A: U17.F4 (DQ4_a), U100.W1 (DDR_CH0_DQ4_A)
DDR_CH0_DQ4_B: U17.U4 (DQ4_b), U100.F1 (DDR_CH0_DQ4_B)
DDR_CH0_DQ5_A: U17.E4 (DQ5_a), U100.V2 (DDR_CH0_DQ5_A)
DDR_CH0_DQ5_B: U17.V4 (DQ5_b), U100.G2 (DDR_CH0_DQ5_B)
DDR_CH0_DQ6_A: U17.C4 (DQ6_a), U100.V1 (DDR_CH0_DQ6_A)
DDR_CH0_DQ6_B: U17.Y4 (DQ6_b), U100.G1 (DDR_CH0_DQ6_B)
DDR_CH0_DQ7_A: U17.B4 (DQ7_a), U100.U2 (DDR_CH0_DQ7_A)
DDR_CH0_DQ7_B: U17.AA4 (DQ7_b), U100.H2 (DDR_CH0_DQ7_B)
DDR_CH0_DQ8_A: U17.B11 (DQ8_a), U100.AB2 (DDR_CH0_DQ8_A)
DDR_CH0_DQ8_B: U17.AA11 (DQ8_b), U100.D2 (DDR_CH0_DQ8_B)
DDR_CH0_DQ9_A: U17.C11 (DQ9_a), U100.AB1 (DDR_CH0_DQ9_A)
DDR_CH0_DQ9_B: U17.Y11 (DQ9_b), U100.C1 (DDR_CH0_DQ9_B)
DDR_CH0_DQ10_A: U17.E11 (DQ10_a), U100.AC1 (DDR_CH0_DQ10_A)
DDR_CH0_DQ10_B: U17.V11 (DQ10_b), U100.C2 (DDR_CH0_DQ10_B)
DDR_CH0_DQ11_A: U17.F11 (DQ11_a), U100.AC2 (DDR_CH0_DQ11_A)
DDR_CH0_DQ11_B: U17.U11 (DQ11_b), U100.B1 (DDR_CH0_DQ11_B)
DDR_CH0_DQ12_A: U17.F9 (DQ12_a), U100.Y1 (DDR_CH0_DQ12_A)
DDR_CH0_DQ12_B: U17.U9 (DQ12_b), U100.F2 (DDR_CH0_DQ12_B)
DDR_CH0_DQ13_A: U17.E9 (DQ13_a), U100.Y2 (DDR_CH0_DQ13_A)
DDR_CH0_DQ13_B: U17.V9 (DQ13_b), U100.E1 (DDR_CH0_DQ13_B)
DDR_CH0_DQ14_A: U17.C9 (DQ14_a), U100.AA1 (DDR_CH0_DQ14_A)
DDR_CH0_DQ14_B: U17.Y9 (DQ14_b), U100.E2 (DDR_CH0_DQ14_B)
DDR_CH0_DQ15_A: U17.B9 (DQ15_a), U100.AA2 (DDR_CH0_DQ15_A)
DDR_CH0_DQ15_B: U17.AA9 (DQ15_b), U100.D1 (DDR_CH0_DQ15_B)
DDR_CH0_DQS0N_A: U17.E3 (DQS0_c_a), U100.U4 (DDR_CH0_DQS0N_A)
DDR_CH0_DQS0N_B: U17.V3 (DQS0_c_b), U100.J7 (DDR_CH0_DQS0N_B)
DDR_CH0_DQS0P_A: U17.D3 (DQS0_t_a), U100.U5 (DDR_CH0_DQS0P_A)
DDR_CH0_DQS0P_B: U17.W3 (DQS0_t_b), U100.J8 (DDR_CH0_DQS0P_B)
DDR_CH0_DQS1N_A: U17.E10 (DQS1_c_a), U100.AA4 (DDR_CH0_DQS1N_A)
DDR_CH0_DQS1N_B: U17.V10 (DQS1_c_b), U100.F4 (DDR_CH0_DQS1N_B)
DDR_CH0_DQS1P_A: U17.D10 (DQS1_t_a), U100.AA5 (DDR_CH0_DQS1P_A)
DDR_CH0_DQS1P_B: U17.W10 (DQS1_t_b), U100.F5 (DDR_CH0_DQS1P_B)
DDR_RESET: U17.T11 (RESET_n), U100.T4 (DDR_CH0_RESET_A); also elsewhere on the board
GND: C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2, C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.2, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C360.2, C361.2, C362.2, C363.2, C364.2, C365.2, C366.2, C367.2, C368.2, C369.2, C370.2, C371.2, C372.2, C373.2, U17.A3 (VSS), U17.A10 (VSS), U17.AB3 (VSS), U17.AB5 (VSS), U17.AB8 (VSS), U17.AB10 (VSS), U17.C1 (VSS), U17.C5 (VSS), U17.C8 (VSS), U17.C12 (VSS), U17.D2 (VSS), U17.D4 (VSS), U17.D9 (VSS), U17.D11 (VSS), U17.E1 (VSS), U17.E5 (VSS), U17.E8 (VSS), U17.E12 (VSS), U17.G1 (VSS), U17.G3 (VSS), U17.G5 (VSS), U17.G8 (VSS), U17.G10 (VSS), U17.G12 (VSS), U17.J1 (VSS), U17.J3 (VSS), U17.J10 (VSS), U17.J12 (VSS), U17.K2 (VSS), U17.K4 (VSS), U17.K9 (VSS), U17.K11 (VSS), U17.N2 (VSS), U17.N4 (VSS), U17.N9 (VSS), U17.N11 (VSS), U17.P1 (VSS), U17.P3 (VSS), U17.P10 (VSS), U17.P12 (VSS), U17.T1 (VSS), U17.T3 (VSS), U17.T5 (VSS), U17.T8 (VSS), U17.T10 (VSS), U17.T12 (VSS), U17.V1 (VSS), U17.V5 (VSS), U17.V8 (VSS), U17.V12 (VSS), U17.W2 (VSS), U17.W4 (VSS), U17.W9 (VSS), U17.W11 (VSS), U17.Y1 (VSS), U17.Y5 (VSS), U17.Y8 (VSS), U17.Y12 (VSS); also elsewhere on the board
VCCA_1V8_S0: C323.1, U100.M12 (DDR_CH0_PLL_AVDD1V8); also elsewhere on the board
VCC_1V8_S3: C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, U17.F1 (VDD1), U17.F12 (VDD1), U17.G4 (VDD1), U17.G9 (VDD1), U17.T4 (VDD1), U17.T9 (VDD1), U17.U1 (VDD1), U17.U12 (VDD1); also elsewhere on the board
VDD2_DDR_S3: C340.1, C341.1, C342.1, C343.1, C344.1, C345.1, C346.1, C347.1, C348.1, C349.1, C350.1, C351.1, C352.1, C353.1, C354.1, R115.2, R116.2, R118.1, U17.A4 (VDD2), U17.A9 (VDD2), U17.AB4 (VDD2), U17.AB9 (VDD2), U17.F5 (VDD2), U17.F8 (VDD2), U17.H1 (VDD2), U17.H5 (VDD2), U17.H8 (VDD2), U17.H12 (VDD2), U17.K1 (VDD2), U17.K3 (VDD2), U17.K10 (VDD2), U17.K12 (VDD2), U17.N1 (VDD2), U17.N3 (VDD2), U17.N10 (VDD2), U17.N12 (VDD2), U17.R1 (VDD2), U17.R5 (VDD2), U17.R8 (VDD2), U17.R12 (VDD2), U17.U5 (VDD2), U17.U8 (VDD2); also elsewhere on the board
VDDA_DDR_PLL_S0: C324.1, U100.N12 (DDR_CH0_PLL_DVDD); also elsewhere on the board
VDDQ_DDR_CKE_S3: C325.1, R118.2, U100.N8 (DDR_CH0_VDDQ_CKE); also elsewhere on the board
VDDQ_DDR_CK_S0: C322.1, R117.2, U100.L10 (DDR_CH0_VDDQ_CK); also elsewhere on the board
VDDQ_DDR_S0: C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C355.1, C356.1, C357.1, C358.1, C359.1, C360.1, C361.1, C362.1, C363.1, C364.1, C365.1, C366.1, C367.1, C368.1, C369.1, C370.1, C371.1, C372.1, C373.1, R111.2, R112.2, R113.2, R114.2, R117.1, U17.AA3 (VDDQ), U17.AA5 (VDDQ), U17.AA8 (VDDQ), U17.AA10 (VDDQ), U17.B3 (VDDQ), U17.B5 (VDDQ), U17.B8 (VDDQ), U17.B10 (VDDQ), U17.D1 (VDDQ), U17.D5 (VDDQ), U17.D8 (VDDQ), U17.D12 (VDDQ), U17.F3 (VDDQ), U17.F10 (VDDQ), U17.U3 (VDDQ), U17.U10 (VDDQ), U17.W1 (VDDQ), U17.W5 (VDDQ), U17.W8 (VDDQ), U17.W12 (VDDQ), U100.M10 (DDR_CH0_VDDQ_0), U100.N10 (DDR_CH0_VDDQ_1), U100.P10 (DDR_CH0_VDDQ_2), U100.R10 (DDR_CH0_VDDQ_3), U100.T10 (DDR_CH0_VDDQ_4); also elsewhere on the board
VDD_DDR_S0: C326.1, C327.1, C328.1, C329.1, C330.1, NT8.1, U100.N13 (DDR_CH0_VDD_MIF_0), U100.P12 (DDR_CH0_VDD_3), U100.P13 (DDR_CH0_VDD_MIF_1), U100.R12 (DDR_CH0_VDD_2), U100.T12 (DDR_CH0_VDD_1), U100.U11 (DDR_CH0_VDD_0); also elsewhere on the board
VDD_DDR_S0_FB: NT8.2; also elsewhere on the board

Notes on the sheet:
Copied from the Radxa Rock 5B v1.45 schematic, sheets 4 and 12. Net names follow the reference, minus 'LP4/4X_'. tools/verify_ddr.py confirms every memory-chip signal ball and its net against the reference page. LPDDR4X only: VDDQ is tied to the 0.6 V rail, and VDD1 is taken straight from VCC_1V8_S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

Schematic: ddr1.kicad_sch, Memory channel 1: LPDDR4X

Parts:
C374, C381, C385, C390, C391, C400, C401, C415, C416: 10uF; C_0603_1608Metric
C375, C376, C380, C382, C383, C384, C388, C402, C403, C417, C418: 1uF; C_0402_1005Metric
C377, C378, C379, C387, C389, C392, C393, C394, C395, C396, C397, C398, C404, C405, C406, C407, C408, C409, C410, C411, C412, C413, C419, C420, C421, C422, C423, C424, C425, C426, C427, C428, C429, C430, C431, C432: 100nF; C_0402_1005Metric
C386: 4.7uF; C_0402_1005Metric
C399, C414: 22uF; C_0603_1608Metric
R119, R120, R121, R122: 49.9R 1%; R_0402_1005Metric
R123, R124, R125, R126: 240R 1%; R_0402_1005Metric
R127, R128: 10K; R_0402_1005Metric
U18: LPDDR4X 200-ball; BGA-200_L15.0-W10.0_K4F8E304HB-MGCJ; Part Samsung K4UBE3D4AA-MGCL (4 GB); any JED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; LCSC C2920257
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588

Connections:
/Memory channel 1: LPDDR4X/DDR_CH1_CKE0_C_SOC: R119.1, U100.D11 (DDR_CH1_LP4/4X_CKE0/LP5_CS0_C)
/Memory channel 1: LPDDR4X/DDR_CH1_CKE0_D_SOC: R120.1, U100.D16 (DDR_CH1_LP4/4X_CKE0/LP5_CS0_D)
/Memory channel 1: LPDDR4X/DDR_CH1_CKE1_C_SOC: R121.1, U100.E11 (DDR_CH1_LP4/4X_CKE1/LP5_CS1_C)
/Memory channel 1: LPDDR4X/DDR_CH1_CKE1_D_SOC: R122.1, U100.E16 (DDR_CH1_LP4/4X_CKE1/LP5_CS1_D)
/Memory channel 1: LPDDR4X/ODT_C: R127.1, U18.G2 (ODT_CA_a)
/Memory channel 1: LPDDR4X/ODT_D: R128.1, U18.T2 (ODT_CA_b)
/Memory channel 1: LPDDR4X/ZQ_MEM1_0: R125.1, U18.A5 (ZQ0)
/Memory channel 1: LPDDR4X/ZQ_MEM1_1: R126.1, U18.A8 (ZQ1)
/Memory channel 1: LPDDR4X/ZQ_SOC_C: R123.1, U100.G8 (DDR_CH1_ZQ_C)
/Memory channel 1: LPDDR4X/ZQ_SOC_D: R124.1, U100.F18 (DDR_CH1_ZQ_D)
DDR_CH1_A0_C: U18.H2 (CA0_a), U100.G12 (DDR_CH1_A0_C)
DDR_CH1_A0_D: U18.R2 (CA0_b), U100.H15 (DDR_CH1_A0_D)
DDR_CH1_A1_C: U18.J2 (CA1_a), U100.F12 (DDR_CH1_A1_C)
DDR_CH1_A1_D: U18.P2 (CA1_b), U100.G14 (DDR_CH1_A1_D)
DDR_CH1_A2_C: U18.H9 (CA2_a), U100.E13 (DDR_CH1_A2_C)
DDR_CH1_A2_D: U18.R9 (CA2_b), U100.G13 (DDR_CH1_A2_D)
DDR_CH1_A3_C: U18.H10 (CA3_a), U100.D13 (DDR_CH1_A3_C)
DDR_CH1_A3_D: U18.R10 (CA3_b), U100.E14 (DDR_CH1_A3_D)
DDR_CH1_A4_C: U18.H11 (CA4_a), U100.A10 (DDR_CH1_A4_C)
DDR_CH1_A4_D: U18.R11 (CA4_b), U100.A15 (DDR_CH1_A4_D)
DDR_CH1_A5_C: U18.J11 (CA5_a), U100.B11 (DDR_CH1_A5_C)
DDR_CH1_A5_D: U18.P11 (CA5_b), U100.B14 (DDR_CH1_A5_D)
DDR_CH1_CKE0_C: R119.2, U18.J4 (CKE0_a)
DDR_CH1_CKE0_D: R120.2, U18.P4 (CKE0_b)
DDR_CH1_CKE1_C: R121.2, U18.J5 (CKE1_a)
DDR_CH1_CKE1_D: R122.2, U18.P5 (CKE1_b)
DDR_CH1_CLKN_C: U18.J9 (CK_c_a), U100.A12 (DDR_CH1_CKB_C)
DDR_CH1_CLKN_D: U18.P9 (CK_c_b), U100.A13 (DDR_CH1_CKB_D)
DDR_CH1_CLKP_C: U18.J8 (CK_t_a), U100.B12 (DDR_CH1_CK_C)
DDR_CH1_CLKP_D: U18.P8 (CK_t_b), U100.B13 (DDR_CH1_CK_D)
DDR_CH1_CS0_C: U18.H4 (CS0_a), U100.G11 (DDR_CH1_LP4/4X_CS0_C)
DDR_CH1_CS0_D: U18.R4 (CS0_b), U100.E19 (DDR_CH1_LP4/4X_CS0_D)
DDR_CH1_CS1_C: U18.H3 (CS1_a), U100.H11 (DDR_CH1_LP4/4X_CS1_C)
DDR_CH1_CS1_D: U18.R3 (CS1_b), U100.D19 (DDR_CH1_LP4/4X_CS1_D)
DDR_CH1_DM0_C: U18.C3 (DMI0_a), U100.F8 (DDR_CH1_DM0_C)
DDR_CH1_DM0_D: U18.Y3 (DMI0_b), U100.D20 (DDR_CH1_DM0_D)
DDR_CH1_DM1_C: U18.C10 (DMI1_a), U100.D4 (DDR_CH1_DM1_C)
DDR_CH1_DM1_D: U18.Y10 (DMI1_b), U100.D22 (DDR_CH1_DM1_D)
DDR_CH1_DQ0_C: U18.B2 (DQ0_a), U100.A8 (DDR_CH1_DQ0_C)
DDR_CH1_DQ0_D: U18.AA2 (DQ0_b), U100.A17 (DDR_CH1_DQ0_D)
DDR_CH1_DQ1_C: U18.C2 (DQ1_a), U100.B9 (DDR_CH1_DQ1_C)
DDR_CH1_DQ1_D: U18.Y2 (DQ1_b), U100.B16 (DDR_CH1_DQ1_D)
DDR_CH1_DQ2_C: U18.E2 (DQ2_a), U100.A9 (DDR_CH1_DQ2_C)
DDR_CH1_DQ2_D: U18.V2 (DQ2_b), U100.A16 (DDR_CH1_DQ2_D)
DDR_CH1_DQ3_C: U18.F2 (DQ3_a), U100.B10 (DDR_CH1_DQ3_C)
DDR_CH1_DQ3_D: U18.U2 (DQ3_b), U100.B15 (DDR_CH1_DQ3_D)
DDR_CH1_DQ4_C: U18.F4 (DQ4_a), U100.A6 (DDR_CH1_DQ4_C)
DDR_CH1_DQ4_D: U18.U4 (DQ4_b), U100.A19 (DDR_CH1_DQ4_D)
DDR_CH1_DQ5_C: U18.E4 (DQ5_a), U100.B7 (DDR_CH1_DQ5_C)
DDR_CH1_DQ5_D: U18.V4 (DQ5_b), U100.B18 (DDR_CH1_DQ5_D)
DDR_CH1_DQ6_C: U18.C4 (DQ6_a), U100.A7 (DDR_CH1_DQ6_C)
DDR_CH1_DQ6_D: U18.Y4 (DQ6_b), U100.A18 (DDR_CH1_DQ6_D)
DDR_CH1_DQ7_C: U18.B4 (DQ7_a), U100.B8 (DDR_CH1_DQ7_C)
DDR_CH1_DQ7_D: U18.AA4 (DQ7_b), U100.B17 (DDR_CH1_DQ7_D)
DDR_CH1_DQ8_C: U18.B11 (DQ8_a), U100.A3 (DDR_CH1_DQ8_C)
DDR_CH1_DQ8_D: U18.AA11 (DQ8_b), U100.A22 (DDR_CH1_DQ8_D)
DDR_CH1_DQ9_C: U18.C11 (DQ9_a), U100.B3 (DDR_CH1_DQ9_C)
DDR_CH1_DQ9_D: U18.Y11 (DQ9_b), U100.B22 (DDR_CH1_DQ9_D)
DDR_CH1_DQ10_C: U18.E11 (DQ10_a), U100.A2 (DDR_CH1_DQ10_C)
DDR_CH1_DQ10_D: U18.V11 (DQ10_b), U100.A23 (DDR_CH1_DQ10_D)
DDR_CH1_DQ11_C: U18.F11 (DQ11_a), U100.B2 (DDR_CH1_DQ11_C)
DDR_CH1_DQ11_D: U18.U11 (DQ11_b), U100.B23 (DDR_CH1_DQ11_D)
DDR_CH1_DQ12_C: U18.F9 (DQ12_a), U100.A5 (DDR_CH1_DQ12_C)
DDR_CH1_DQ12_D: U18.U9 (DQ12_b), U100.A20 (DDR_CH1_DQ12_D)
DDR_CH1_DQ13_C: U18.E9 (DQ13_a), U100.B5 (DDR_CH1_DQ13_C)
DDR_CH1_DQ13_D: U18.V9 (DQ13_b), U100.B20 (DDR_CH1_DQ13_D)
DDR_CH1_DQ14_C: U18.C9 (DQ14_a), U100.A4 (DDR_CH1_DQ14_C)
DDR_CH1_DQ14_D: U18.Y9 (DQ14_b), U100.A21 (DDR_CH1_DQ14_D)
DDR_CH1_DQ15_C: U18.B9 (DQ15_a), U100.B4 (DDR_CH1_DQ15_C)
DDR_CH1_DQ15_D: U18.AA9 (DQ15_b), U100.B21 (DDR_CH1_DQ15_D)
DDR_CH1_DQS0N_C: U18.E3 (DQS0_c_a), U100.D9 (DDR_CH1_DQS0N_C)
DDR_CH1_DQS0N_D: U18.V3 (DQS0_c_b), U100.G16 (DDR_CH1_DQS0N_D)
DDR_CH1_DQS0P_C: U18.D3 (DQS0_t_a), U100.E9 (DDR_CH1_DQS0P_C)
DDR_CH1_DQS0P_D: U18.W3 (DQS0_t_b), U100.H16 (DDR_CH1_DQS0P_D)
DDR_CH1_DQS1N_C: U18.E10 (DQS1_c_a), U100.D5 (DDR_CH1_DQS1N_C)
DDR_CH1_DQS1N_D: U18.V10 (DQS1_c_b), U100.E21 (DDR_CH1_DQS1N_D)
DDR_CH1_DQS1P_C: U18.D10 (DQS1_t_a), U100.E5 (DDR_CH1_DQS1P_C)
DDR_CH1_DQS1P_D: U18.W10 (DQS1_t_b), U100.D21 (DDR_CH1_DQS1P_D)
DDR_RESET: U18.T11 (RESET_n); also elsewhere on the board
GND: C374.2, C375.2, C376.2, C377.2, C378.2, C379.2, C380.2, C381.2, C382.2, C383.2, C384.2, C385.2, C386.2, C387.2, C388.2, C389.2, C390.2, C391.2, C392.2, C393.2, C394.2, C395.2, C396.2, C397.2, C398.2, C399.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C428.2, C429.2, C430.2, C431.2, C432.2, U18.A3 (VSS), U18.A10 (VSS), U18.AB3 (VSS), U18.AB5 (VSS), U18.AB8 (VSS), U18.AB10 (VSS), U18.C1 (VSS), U18.C5 (VSS), U18.C8 (VSS), U18.C12 (VSS), U18.D2 (VSS), U18.D4 (VSS), U18.D9 (VSS), U18.D11 (VSS), U18.E1 (VSS), U18.E5 (VSS), U18.E8 (VSS), U18.E12 (VSS), U18.G1 (VSS), U18.G3 (VSS), U18.G5 (VSS), U18.G8 (VSS), U18.G10 (VSS), U18.G12 (VSS), U18.J1 (VSS), U18.J3 (VSS), U18.J10 (VSS), U18.J12 (VSS), U18.K2 (VSS), U18.K4 (VSS), U18.K9 (VSS), U18.K11 (VSS), U18.N2 (VSS), U18.N4 (VSS), U18.N9 (VSS), U18.N11 (VSS), U18.P1 (VSS), U18.P3 (VSS), U18.P10 (VSS), U18.P12 (VSS), U18.T1 (VSS), U18.T3 (VSS), U18.T5 (VSS), U18.T8 (VSS), U18.T10 (VSS), U18.T12 (VSS), U18.V1 (VSS), U18.V5 (VSS), U18.V8 (VSS), U18.V12 (VSS), U18.W2 (VSS), U18.W4 (VSS), U18.W9 (VSS), U18.W11 (VSS), U18.Y1 (VSS), U18.Y5 (VSS), U18.Y8 (VSS), U18.Y12 (VSS); also elsewhere on the board
VCCA_1V8_S0: C382.1, U100.K16 (DDR_CH1_PLL_AVDD1V8); also elsewhere on the board
VCC_1V8_S3: C390.1, C391.1, C392.1, C393.1, C394.1, C395.1, C396.1, C397.1, C398.1, U18.F1 (VDD1), U18.F12 (VDD1), U18.G4 (VDD1), U18.G9 (VDD1), U18.T4 (VDD1), U18.T9 (VDD1), U18.U1 (VDD1), U18.U12 (VDD1); also elsewhere on the board
VDD2_DDR_S3: C399.1, C400.1, C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, R127.2, R128.2, U18.A4 (VDD2), U18.A9 (VDD2), U18.AB4 (VDD2), U18.AB9 (VDD2), U18.F5 (VDD2), U18.F8 (VDD2), U18.H1 (VDD2), U18.H5 (VDD2), U18.H8 (VDD2), U18.H12 (VDD2), U18.K1 (VDD2), U18.K3 (VDD2), U18.K10 (VDD2), U18.K12 (VDD2), U18.N1 (VDD2), U18.N3 (VDD2), U18.N10 (VDD2), U18.N12 (VDD2), U18.R1 (VDD2), U18.R5 (VDD2), U18.R8 (VDD2), U18.R12 (VDD2), U18.U5 (VDD2), U18.U8 (VDD2); also elsewhere on the board
VDDA_DDR_PLL_S0: C383.1, U100.L15 (DDR_CH1_PLL_DVDD); also elsewhere on the board
VDDQ_DDR_CKE_S3: C384.1, U100.H13 (DDR_CH1_VDDQ_CKE); also elsewhere on the board
VDDQ_DDR_CK_S0: C380.1, C381.1, U100.M13 (DDR_CH1_VDDQ_CK); also elsewhere on the board
VDDQ_DDR_S0: C374.1, C375.1, C376.1, C377.1, C378.1, C379.1, C414.1, C415.1, C416.1, C417.1, C418.1, C419.1, C420.1, C421.1, C422.1, C423.1, C424.1, C425.1, C426.1, C427.1, C428.1, C429.1, C430.1, C431.1, C432.1, R123.2, R124.2, R125.2, R126.2, U18.AA3 (VDDQ), U18.AA5 (VDDQ), U18.AA8 (VDDQ), U18.AA10 (VDDQ), U18.B3 (VDDQ), U18.B5 (VDDQ), U18.B8 (VDDQ), U18.B10 (VDDQ), U18.D1 (VDDQ), U18.D5 (VDDQ), U18.D8 (VDDQ), U18.D12 (VDDQ), U18.F3 (VDDQ), U18.F10 (VDDQ), U18.U3 (VDDQ), U18.U10 (VDDQ), U18.W1 (VDDQ), U18.W5 (VDDQ), U18.W8 (VDDQ), U18.W12 (VDDQ), U100.K11 (DDR_CH1_VDDQ_0), U100.K12 (DDR_CH1_VDDQ_1), U100.K13 (DDR_CH1_VDDQ_2), U100.K14 (DDR_CH1_VDDQ_3), U100.K15 (DDR_CH1_VDDQ_4); also elsewhere on the board
VDD_DDR_S0: C385.1, C386.1, C387.1, C388.1, C389.1, U100.L11 (DDR_CH1_VDD_0), U100.L12 (DDR_CH1_VDD_1), U100.L13 (DDR_CH1_VDD_2), U100.L14 (DDR_CH1_VDD_3), U100.L17 (DDR_CH1_VDD_MIF_0), U100.L18 (DDR_CH1_VDD_MIF_1); also elsewhere on the board

Notes on the sheet:
Copied from the Radxa Rock 5B v1.45 schematic, sheets 4 and 12. Net names follow the reference, minus 'LP4/4X_'. tools/verify_ddr.py confirms every memory-chip signal ball and its net against the reference page. LPDDR4X only: VDDQ is tied to the 0.6 V rail, and VDD1 is taken straight from VCC_1V8_S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

Schematic: soc_system.kicad_sch, Processor: clock, reset, IO supplies, GPIO bank 0

Parts:
C433, C435, C439, C444: 1uF; C_0402_1005Metric
C434, C436, C437, C438, C440, C441, C442, C443, C445, C446, C447, C448, C449, C450, C451, C452, C453, C454, C455, C458: 100nF; C_0402_1005Metric
C456, C457: 18pF; C_0402_1005Metric
C459: 1nF; C_0402_1005Metric
J9: USB download; PinHeader_1x02_P2.54mm_Vertical
R129, R134, R139, R140: 22R; R_0402_1005Metric
R130: 510K 1%; R_0402_1005Metric
R131: 0R; R_0402_1005Metric
R132, R135, R137: 100K; R_0402_1005Metric
R133: 10K; R_0402_1005Metric
R136, R138: 120K; R_0402_1005Metric
R141, R142, R143, R144, R145, R146: 2.2K; R_0402_1005Metric
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588
Y3: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Processor: clock, reset, IO supplies, GPIO bank 0/BOOT_SARADC_IN0: J9.1, R132.2, U100.AM16 (SARADC_IN0_BOOT)
/Processor: clock, reset, IO supplies, GPIO bank 0/GPIO0_A2_PIN: R134.1, U100.R32 (PMIC_SLEEP1/GPIO0_A2_d)
/Processor: clock, reset, IO supplies, GPIO bank 0/GPIO0_A5_PIN: R139.1, U100.N31 (SPI2_CLK_M2/SDMMC_PWREN/PMU_DEBUG/GPIO0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)
/Processor: clock, reset, IO supplies, GPIO bank 0/GPIO0_A6_PIN: R140.1, U100.N30 (SPI2_MOSI_M2/I2C0_SDA_M0/GPIO0_A6_z)
/Processor: clock, reset, IO supplies, GPIO bank 0/GPIO0_C2_PIN: R135.1, U100.T32 (PMIC_SLEEP4/GPIO0_C2_d)
/Processor: clock, reset, IO supplies, GPIO bank 0/GPIO0_C3_PIN: R137.1, U100.T30 (PMIC_SLEEP5/GPIO0_C3_d)
/Processor: clock, reset, IO supplies, GPIO bank 0/XIN24M: C457.1, R130.2, U100.R34 (XIN_24M), Y3.3
/Processor: clock, reset, IO supplies, GPIO bank 0/XOUT24M: R129.1, R130.1, U100.T34 (XOUT_24M)
/Processor: clock, reset, IO supplies, GPIO bank 0/XTAL_X1: C456.1, R129.2, Y3.1
BT_DISABLE_L: U100.P30 (I2S1_SDI0_M1/GPU_AVS/UART0_TX_M0/I2C4_S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); also elsewhere on the board
CPU_BIG0_VSEL: U100.R31 (PMIC_SLEEP2/GPIO0_A3_d); also elsewhere on the board
CPU_BIG1_VSEL: U100.W28 (PMIC_SLEEP6/PDM0_SDI3_M1/GPIO0_D6_d); also elsewhere on the board
FAN_PWM: U100.T31 (I2S1_SCLK_RX_M1/PDM0_CLK0_M1/PWM1_M0/I2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); also elsewhere on the board
GND: C433.2, C434.2, C435.2, C436.2, C437.2, C438.2, C439.2, C440.2, C441.2, C442.2, C443.2, C444.2, C445.2, C446.2, C447.2, C448.2, C449.2, C450.2, C451.2, C452.2, C453.2, C454.2, C455.2, C456.2, C457.2, C458.2, C459.2, J9.2, R136.2, R138.2, U100.M29 (TVSS_d), Y3.2 (G), Y3.4 (G); also elsewhere on the board
I2C0_SCL_M2: R141.2, U100.W30 (I2S1_SDO0_M1/CPU_BIG0_AVS/I2C0_SCL_M2/U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); also elsewhere on the board
I2C0_SDA_M2: R142.2, U100.W29 (I2S1_SDO1_M1/I2C0_SDA_M2/UART1_RX_M2/HD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); also elsewhere on the board
I2C1_SCL_M2: R143.2, U100.V29 (I2S1_SDO2_M1/PDM0_SDI2_M1/PWM3_IR_M0/I2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); also elsewhere on the board
I2C1_SDA_M2: R144.2, U100.V28 (I2S1_SDO3_M1/CPU_BIG1_AVS/I2C1_SDA_M2/C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); also elsewhere on the board
I2C6_SCL_M0: R145.2, U100.W31 (I2S1_SDI3_M1/PDM0_SDI1_M1/I2C6_SCL_M0/U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); also elsewhere on the board
I2C6_SDA_M0: R146.2, U100.V31 (I2S1_SDI2_M1/PDM0_SDI0_M1/I2C6_SDA_M0/U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); also elsewhere on the board
MODEM_DISABLE_L: U100.T29 (I2S1_SDI1_M1/NPU_AVS/UART0_RTSN/PWM5_M1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); also elsewhere on the board
MODEM_PWR_EN: U100.U33 (LITCPU_AVS/SPI3_CLK_M2/GPIO0_D3_u); also elsewhere on the board
MODEM_RESET_H: U100.T28 (I2S1_LRCK_TX_M1/PWM0_M0/I2C2_SCL_M0/CAN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); also elsewhere on the board
NPU_VSEL: U100.U32 (PMIC_SLEEP3/GPIO0_C1_d); also elsewhere on the board
PMIC_INT_L: U100.M30 (PMIC_INT_L/GPIO0_A7_u); also elsewhere on the board
PMIC_PWR_CTRL1: R134.2; also elsewhere on the board
PMIC_PWR_CTRL2: R137.2, R138.1; also elsewhere on the board
PMIC_PWR_CTRL3: R135.2, R136.1; also elsewhere on the board
PMIC_SPI_CLK: R139.2; also elsewhere on the board
PMIC_SPI_CS: U100.K30 (SPI2_CS0_M2/I2C1_SDA_M1/PWM5_M0/UART0_T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); also elsewhere on the board
PMIC_SPI_MOSI: R140.2, U100.L29 (SPI2_MISO_M2/I2C0_SCL_M0/GPIO0_B3_z); also elsewhere on the board
RECOVERY_KEY: C459.1, R133.2, U100.AL16 (SARADC_IN1)
RESET_L: C458.1, R131.1, U100.M31 (NPOR_u); also elsewhere on the board
RTC_INT_L: U100.L30 (SPI2_CS1_M2/I2C1_SCL_M1/UART0_RX_M1/GPI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); also elsewhere on the board
TSADC_SHUT_H: R131.2, U100.P32 (TSADC_SHUT_ORG/TSADC_SHUT/GPIO0_A1_z)
UART2_RX_DEBUG: U100.R29 (I2S1_SCLK_TX_M1/JTAG_TMS_M2/I2C1_SDA_M0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); also elsewhere on the board
UART2_TX_DEBUG: U100.P29 (I2S1_MCLK_M1/JTAG_TCK_M2/I2C1_SCL_M0/UA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); also elsewhere on the board
VCCA_1V8_S0: C434.1, C435.1, C437.1, C445.1, R132.1, R133.1, U100.AH18 (SARADC_AVDD_1V8), U100.N27 (OSC_1V8), U100.U18 (PLL_AVDD1V8); also elsewhere on the board
VCCIO_SD_S0: C447.1, U100.Y7 (VCCIO2); also elsewhere on the board
VCC_1V8_S0: C446.1, C448.1, C449.1, C450.1, C451.1, C453.1, C455.1, U100.AA7 (VCCIO2_1V8), U100.AC25 (VCCIO6_1V8), U100.G20 (VCCIO1_1V8), U100.H20 (VCCIO4_1V8), U100.H21 (VCCIO4), U100.W25 (VCCIO5_1V8), U100.Y26 (VCCIO3_1V8); also elsewhere on the board
VCC_1V8_S3: C433.1, C440.1, C442.1, U100.N28 (PMUIO1_1V8), U100.R27 (PMUIO2_1V8), U100.V26 (EMMCIO_1V8); also elsewhere on the board
VCC_3V3_S0: C452.1, C454.1, U100.AC26 (VCCIO6), U100.W26 (VCCIO5); also elsewhere on the board
VCC_3V3_S3: C441.1, R141.1, R142.1, R143.1, R144.1, R145.1, R146.1, U100.P28 (PMUIO2); also elsewhere on the board
VDD_0V75_S0: C436.1, C438.1, C439.1, U100.AD3 (OTP_VDDOTP_0V75), U100.V20 (PLL_DVDD0V75); also elsewhere on the board
VDD_0V75_S3: C443.1, C444.1, U100.P27 (PMU_0V75); also elsewhere on the board
WIFI_DISABLE_L: U100.R30 (I2S1_LRCK_RX_M1/PDM0_CLK1_M1/PWM2_M0/UA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); also elsewhere on the board

Notes on the sheet:
RK3588 units 12 (system) and 6 (GPIO bank 0), from the Radxa Rock 5B v1.45 schematic, sheets 11, 13, 15 and 19. IO bank voltages as the reference: banks on VCCIO5 and VCCIO6 run at 3.3 V, PMUIO2 at 3.3 V, the rest at 1.8 V. Boot select (SARADC_IN0) has only the 100K pull-up: boot order SPI flash, e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

Schematic: soc_gpio12.kicad_sch, Processor: GPIO banks 1 and 2

Parts:
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588

Connections:
EMMC_CLK: U100.V34 (EMMC_CLKOUT/GPIO2_A1_d); also elsewhere on the board
EMMC_CMD: U100.W34 (EMMC_CMD/FSPI_CLK_M0/GPIO2_A0_u); also elsewhere on the board
EMMC_D0: U100.Y33 (EMMC_D0/FSPI_D0_M0/GPIO2_D0_u); also elsewhere on the board
EMMC_D1: U100.W33 (EMMC_D1/FSPI_D1_M0/GPIO2_D1_u); also elsewhere on the board
EMMC_D2: U100.V32 (EMMC_D2/FSPI_D2_M0/GPIO2_D2_u); also elsewhere on the board
EMMC_D3: U100.AA33 (EMMC_D3/FSPI_D3_M0/GPIO2_D3_u); also elsewhere on the board
EMMC_D4: U100.Y32 (EMMC_D4/I2C1_SCL_M3/UART5_RX_M2/GPIO2_D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); also elsewhere on the board
EMMC_D5: U100.AA32 (EMMC_D5/I2C1_SDA_M3/UART5_TX_M2/GPIO2_D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); also elsewhere on the board
EMMC_D6: U100.W32 (EMMC_D6/FSPI_CS0N_M0/GPIO2_D6_u); also elsewhere on the board
EMMC_D7: U100.V33 (EMMC_D7/FSPI_CS1N_M0/GPIO2_D7_u); also elsewhere on the board
EMMC_DS: U100.Y34 (EMMC_DATA_STROBE/I2C2_SDA_M2/UART5_CTSN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); also elsewhere on the board
EMMC_RST_L: U100.AA34 (EMMC_RSTN/I2C2_SCL_M2/UART5_RTSN_M1/GPI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); also elsewhere on the board

Notes on the sheet:
Bank 1 (1.8 V) is unused on this board. Bank 2 carries the eMMC interface, as the reference; its other pins (1.8 V) are unused. The eMMC chip itself is not drawn yet.

Schematic: soc_gpio34.kicad_sch, Processor: GPIO banks 3 and 4

Parts:
R147, R148: 2.2K; R_0402_1005Metric
U100: RK3588; FCBGA-1088_L23.0-W23.0-P0.65-TL_RK3588

Connections:
I2C7_SCL_M3: R147.2, U100.AK25 (CIF_HREF/BT1120_D8/I2S1_SDO1_M0/PCIE30X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); also elsewhere on the board
I2C7_SDA_M3: R148.2, U100.AM25 (CIF_VSYNC/BT1120_D9/I2S1_SDO2_M0/PCIE20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); also elsewhere on the board
MODEM_VCC_EN: U100.AH29 (GMAC1_RXDV_CRS/I2S2_LRCK_RX_M1/MIPI_CAM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); also elsewhere on the board
PCIE_ACCEL_CLKREQ_L: U100.AK24 (BT1120_D15/SPDIF1_TX_M2/PCIE20X1_2_PERS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); also elsewhere on the board
PCIE_ACCEL_PERST_L: U100.AK26 (CIF_CLKIN/BT1120_CLKOUT/I2S1_SDI3_M0/PC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); also elsewhere on the board
PCIE_ETH1_CLKREQ_L: U100.AL29 (CIF_D3/BT1120_D3/I2S1_SCLK_RX_M0/PCIE30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); also elsewhere on the board
PCIE_ETH1_PERST_L: U100.AK27 (CIF_D5/BT1120_D5/I2S1_SDI0_M0/PCIE30X1_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); also elsewhere on the board
PCIE_ETH2_CLKREQ_L: U100.AK30 (CIF_D0/BT1120_D0/I2S1_MCLK_M0/PCIE30X1_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); also elsewhere on the board
PCIE_ETH2_PERST_L: U100.AM29 (CIF_D2/BT1120_D2/I2S1_LRCK_TX_M0/PCIE30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); also elsewhere on the board
PCIE_NVME_CLKREQ_L: U100.AL26 (CIF_CLKOUT/BT1120_D10/I2S1_SDO3_M0/PCIE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); also elsewhere on the board
PCIE_NVME_PERST_L: U100.AJ27 (BT1120_D12/PCIE30X4_PERSTN_M1/HDMI_RX_H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); also elsewhere on the board
PCIE_WAKE_L: U100.AJ26 (BT1120_D11/PCIE30X4_WAKEN_M1/HDMI_RX_CE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); also elsewhere on the board
PCIE_WIFI_CLKREQ_L: U100.AJ24 (CIF_D11/PCIE20X1_2_CLKREQN_M0/HDMI_TX0_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); also elsewhere on the board
PCIE_WIFI_PERST_L: U100.AG28 (GMAC1_RXD1/I2S2_SCLK_RX_M1/MIPI_CAMERA3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); also elsewhere on the board
PD1_INT_L: U100.AC29 (GMAC1_TXD1/I2S2_MCLK_M1/UART2_CTSN/GPIO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); also elsewhere on the board
PD2_INT_L: U100.AE28 (GMAC1_TXER/I2S2_SDI_M1/UART2_RX_M2/PWM3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); also elsewhere on the board
SPI1_CLK_TPM: U100.Y27 (GMAC1_PPSCLK/PCIE30X2_BUTTON_RSTN/UART7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); also elsewhere on the board
SPI1_CS0_TPM: U100.Y31 (GMAC1_MDC/MIPI_TE0/I2C8_SCL_M4/UART7_RT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); also elsewhere on the board
SPI1_MISO_TPM: U100.Y29 (GMAC1_PPSTRIG/I2C3_SDA_M1/UART7_TX_M1/S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); also elsewhere on the board
SPI1_MOSI_TPM: U100.AA28 (GMAC1_PTP_REF_CLK/HDMI_TX1_HPD_M1/I2C3_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); also elsewhere on the board
THREAD_BOOT: U100.AG29 (GMAC1_RXD0/MIPI_CAMERA2_CLK_M1/PWM8_M0/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); also elsewhere on the board
THREAD_RESET_L: U100.AH27 (ETH1_REFCLKO_25M/MIPI_CAMERA1_CLK_M1/I2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); also elsewhere on the board
TPM_INT_L: U100.Y30 (GMAC1_MDIO/MIPI_TE1/I2C8_SDA_M4/UART7_C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); also elsewhere on the board
UART3_RX_THREAD: U100.AE29 (GMAC1_MCLKINOUT/I2S2_LRCK_TX_M1/CAN1_TX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); also elsewhere on the board
UART3_TX_THREAD: U100.AD29 (GMAC1_TXEN/I2S2_SCLK_TX_M1/CAN1_RX_M0/U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); also elsewhere on the board
USBC1_SBU1_DC: U100.AL27 (CIF_D6/BT1120_D6/I2S1_SDI1_M0/PCIE30X2_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); also elsewhere on the board
USBC1_SBU2_DC: U100.AM27 (CIF_D7/BT1120_D7/I2S1_SDI2_M0/PCIE30X2_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); also elsewhere on the board
USBC2_SBU1_DC: U100.AJ28 (BT1120_D13/PCIE20X1_2_CLKREQN_M1/HDMI_T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); also elsewhere on the board
USBC2_SBU2_DC: U100.AJ25 (BT1120_D14/PCIE20X1_2_WAKEN_M1/HDMI_TX0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); also elsewhere on the board
USBC2_VBUS_EN: U100.AL28 (CIF_D4/BT1120_D4/I2S1_LRCK_RX_M0/PCIE30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); also elsewhere on the board
USB_HOST_PWREN_H: U100.AL24 (MIPI_CAMERA0_CLK_M0/SPDIF1_TX_M1/I2S1_S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); also elsewhere on the board
VCC_3V3_S0: R147.1, R148.1; also elsewhere on the board

Notes on the sheet:
Banks 3 and 4 run at 3.3 V (pins GPIO4_C2-C6 at 1.8 V, GPIO4_D0-D5 on the SD supply: unused). PCIe reset and clock-request lines sit on each controller's own M1 pins. Assignments are in GPIO_USE in build.py; those marked 'this board' are new and not from the reference.
